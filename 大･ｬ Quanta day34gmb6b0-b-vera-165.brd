# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Nets (continued)
PCIE_CLKREQ_CR#: R535.1 U19.2 U25.U5
PCIE_CLKREQ_LAN#: R142.1 R519.1 U25.N1
PCIE_CLKREQ_WLAN#: CN22.7 R530.1 U25.AD1
PCIE_RCOMP: R150.1 U25.A27
PCIE_RXN3_WLAN: CN22.23 U25.G11
PCIE_RXN4_LAN: C225.2 U25.F13
PCIE_RXN4_LAN_L: C225.1 U8.18
PCIE_RXN5_CARD: C541.1 U25.F10
PCIE_RXN5_CARD_C: C541.2 U19.8
PCIE_RXP3_WLAN: CN22.25 U25.F11
PCIE_RXP4_LAN: C226.2 U25.G13
PCIE_RXP4_LAN_L: C226.1 U8.17
PCIE_RXP5_CARD: C549.1 U25.E10
PCIE_RXP5_CARD_C: C549.2 U19.7
PCIE_TXN3_WLAN: C256.2 CN22.31
PCIE_TXN3_WLAN_C: C256.1 U25.C29
PCIE_TXN4_LAN: C698.2 U8.14
PCIE_TXN4_LAN_C: C698.1 U25.B29
PCIE_TXN5_CARD: C705.2 U19.4
PCIE_TXN5_CARD_C: C705.1 U25.C23
PCIE_TXP3_WLAN: C244.2 CN22.33
PCIE_TXP3_WLAN_C: C244.1 U25.B30
PCIE_TXP4_LAN: C701.2 U8.13
PCIE_TXP4_LAN_C: C701.1 U25.A29
PCIE_TXP5_CARD: C711.2 U19.3
PCIE_TXP5_CARD_C: C711.1 U25.C22
PCIE_WAKE#: EC12.1 Q5.3 R146.2 R259.1 R407.1 U11.17 U25.AJ5
PCIE_WAKE#_R: R146.1 U8.21
PD#: D11.2 D14.1 Q29.3 R344.2 R404.2 R420.2 R421.1 U14.1 U14.2 U20.47
PD#_R: D14.3 R404.1 R627.2 R7484.1 U21.7 U21.8
PIRQC#: R516.1 U25.N4
PIRQD#: R518.1 U25.N2
PLTRST#: CN22.17 CN22.22 EC58.1 EC59.1 R258.2 R262.1 R365.2 U8.19 U11.22 U18.16 U19.1 U25.AG7
PM_BATLOW#: R168.1 R178.2 U25.AN4
PM_EXTTS#0: JDIM1.198 JDIM2.198 R334.2 U16.6
PM_THRMTRIP#: C328.1 Q15.1 R184.1 U25.D60
PN_BLON: D1.2 R5.2 R7.2
PROC_OPI_RCOMP: R584.2 U25.AY15
PROCHOT#: R517.2 U25.K63
PROCPWRGD: R495.2 U25.C61
PWR_DEBUG: CN8.53 R555.2 R556.1 U25.H59
PWR_LED#: C70.2 Q1.2 U11.24
R_SPK+: L3.2 U20.44
R_SPK+_R: C25.2 CN3.1 L3.1
R_SPK-: L4.2 U20.43
R_SPK-_R: C30.2 CN3.2 L4.1
REGN6V: PC239.2 PD4.2 PR217.2 PU1.16
RF_LINK#: CN22.44 CN22.46 R458.2 U11.109
RF_OFF_PCH: Q3.2 R177.1 R178.1
RF_OFF_PCH_R: R172.1 R177.2 U25.AM2
RSMRST#: EC25.2 R578.1 R579.2 U11.119 U25.AW6
RTC_RST#: C367.1 CN9.9 J1.1 Q19.3 R265.2 R277.2 U25.AU7
RTC_X1: C369.2 R573.1 R582.2 U25.AW5 Y4.1
RTC_X2: C360.2 R573.2 TP35.1 U25.AY5 Y4.2
RTS5237_AV12: C525.2 C526.2 C527.1 U19.10 U19.14
RTS5237_GPIO: R406.1 U19.28
RTS5237_RREF: C528.2 R372.1 U19.9
S5_ON: PR112.1 PR185.2 R228.2 U11.100
SATA3GP: R550.1 U25.AC1
SATA_LED#: CN14.19 EC78.1 R536.1 U25.U3
SATA_RCOMP: R485.2 U25.C12
SATA_RXN0: C794.2 U25.J5
SATA_RXN0_17: C794.1 HD17.5
SATA_RXN1: C756.1 R295.2 U25.J6
SATA_RXN1_NG: C779.1 R295.1
SATA_RXN1_NG_C: C779.2 CN29.43
SATA_RXN1_SSD: C756.2 CN26.25
SATA_RXN2: C728.2 C730.2 U25.J8
SATA_RXN2_15: C730.1 ODD15.5
SATA_RXN14_C: C728.1 ODD14.5
SATA_RXP0: C793.2 U25.H5
SATA_RXP0_17: C793.1 HD17.6
SATA_RXP1: C750.1 R292.2 U25.H6
SATA_RXP1_NG: C778.1 R292.1
SATA_RXP1_NG_C: C778.2 CN29.41
SATA_RXP1_SSD: C750.2 CN26.23
SATA_RXP2: C727.2 C729.2 U25.H8
SATA_RXP2_15: C729.1 ODD15.6
SATA_RXP14_C: C727.1 ODD14.6
SATA_TXN0: C795.2 U25.B15
SATA_TXN0_17: C795.1 HD17.3
SATA_TXN1: C757.1 R297.2 U25.B14
SATA_TXN1_NG: C780.1 R297.1
SATA_TXN1_NG_C: C780.2 CN29.47
SATA_TXN1_SSD: C757.2 CN26.31
SATA_TXN2: C731.2 C732.2 U25.A17
SATA_TXN2_15: C731.1 ODD15.3
SATA_TXN14_C: C732.1 ODD14.3
SATA_TXP0: C796.2 U25.A15
SATA_TXP0_17: C796.1 HD17.2
SATA_TXP1: C759.1 R300.2 U25.C15
SATA_TXP1_NG: C782.1 R300.1
SATA_TXP1_NG_C: C782.2 CN29.49
SATA_TXP1_SSD: C759.2 CN26.33
SATA_TXP2: C733.2 C734.2 U25.B17
SATA_TXP2_15: C733.1 ODD15.2
SATA_TXP14_C: C734.1 ODD14.2
SCLK: PR78.2 PR79.1 PU3.5
SD_CD#: CN15.11 U19.30
SD_CLK_R: R390.1 U19.17
SD_CMD_R: R396.1 U19.19
SD_D0_R: R377.1 U19.16
SD_D1: CN15.8 EC41.1 R378.2
SD_D1_R: R378.1 U19.15
SD_D2_R: R402.1 U19.21
SD_D3_R: R398.1 U19.20
SDIO: PR83.2 PR84.1 PU3.3
SDIO_CLK: RP2.4 U25.E3
SDIO_CMD: RP2.3 U25.F4
SDIO_D1: RP2.2 U25.E4
SDIO_D2: RP2.1 U25.C3
SDIO_D3: RP6.4 U25.E2
SDVO_CLK: Q14.4 R188.2 U25.B9
SDVO_DATA: Q14.1 R187.2 U25.C9
SENSE_A: CN14.7 R428.2
SENSE_A_1: R428.1 U20.13
SERIRQ: R529.1 U11.5 U18.27 U25.T4
SIO_EXT_SCI#: R282.1 U11.23 U25.AU2
SIO_EXT_SMI#: R528.1 U11.15 U25.U1
SLP_A#: CN9.6 U25.AL5
SLP_S5#: CN9.4 U25.AP5
SLP_SUS#_EC: U11.90 U25.AP4
SLP_SUS_ON: C724.2 R563.2 U11.89 U26.3
SM_INTRUDER#: R577.2 U25.AU6
SM_RCOMP_0: R251.1 U25.AU60
SM_RCOMP_1: R250.1 U25.AV60
SM_RCOMP_2: R249.1 U25.AU61
SM_VREF: C540.1 R380.1 U25.AP49
SMB_ME0_CLK: R569.2 U25.AN1
SMB_ME0_DAT: R568.2 U25.AK1
SMB_ME1_CLK: Q38.3 R572.2 U25.AU3
SMB_ME1_DAT: Q38.6 R560.2 U25.AH3
SMB_PCH_CLK: Q12.6 R570.2 U25.AP2
SMB_PCH_DAT: Q12.3 R566.2 U25.AH1
SMB_RUN_CLK: CN8.57 JDIM1.202 JDIM2.202 Q12.1 Q27.4 R194.2
SMB_RUN_DAT: CN8.56 JDIM1.200 JDIM2.200 Q12.4 Q27.1 R185.2
SMBALERT#: R186.1 U25.AN2
SMC: BAT14.4 BAT15.4 BAT17.10 PR2.1
SMD: BAT14.3 BAT15.3 BAT17.11 PR1.1
SMDDR_VREF_DQ0_M3: C468.1 R350.1 U25.AR51
SMDDR_VREF_DQ1_M3: C440.1 R331.1 U25.AP51
SML0ALERT#: R192.2 U25.AL2
SML1ALERT#: R238.2 TP10.1 U25.AU4
SRTC_RST#: C358.1 R256.2 R265.1 U25.AV6
SUB_OUT: R608.2 R609.2 U20.37
SUB_OUT14: C8738.1 R609.1
SUB_OUT14_1: C591.1 C592.1 R604.1 R605.1
SUB_OUT15: C460.1 R608.1
SUB_OUT+: CN6.2 EC20.1 L12.2
SUB_OUT+_L: C406.1 EC73.1 R628.1 U14.23 U14.25
SUB_OUT+_L_4P: L40.1 U21.2
SUB_OUT+_L_C: CN17.1 EC63.1 L40.2
SUB_OUT+_R_4P_1: L36.1 U21.14
SUB_OUT+_R_4P_15: L12.1 R628.2
SUB_OUT+_R_C: CN17.4 EC64.1 L36.2
SUB_OUT-: CN6.1 EC21.1 L14.2
SUB_OUT-_L: C407.1 EC74.1 R621.1 U14.18 U14.20
SUB_OUT-_L_4P: L41.1 U21.5
SUB_OUT-_L_C: CN17.2 EC68.1 L41.2
SUB_OUT-_R_4P_1: L39.1 U21.11
SUB_OUT-_R_4P_15: L14.1 R621.2
SUB_OUT-_R_C: CN17.3 EC66.1 L39.2
SUB_OUT_L+: C593.2 Q820.4 U21.20
SUB_OUT_LC: C592.2 R425.2
SUB_OUT_LR: Q820.1 R425.1 U21.19
SUB_OUT_R+: C590.2 Q821.4 U21.16
SUB_OUT_RC: C591.2 R424.2
SUB_OUT_RR: Q821.1 R424.1 U21.17
SUSACK#: R567.1 R7471.2 R7472.2 U25.AK2
SUSACK#_EC: R7472.1 U11.82
SUSB#: CN9.2 CN9.15 R283.1 U11.88 U25.AT4
SUSC#: CN9.5 U11.18 U25.AJ6
SUSON: PR118.1 PR130.1 U11.35
SUSWARN#: R588.1 R7471.1 R7473.2 U25.AV4
SUSWARN#_EC: R7473.1 U11.3
SWN: PR80.2 PR158.1
SY8208BBST: PR178.2 PU11.6
SY8208BBST_S: PC213.1 PR178.1
SY8208BEN: PC209.2 PR112.2 PR179.1 PU11.1
SY8208BFB: PR177.1 PU11.3
SY8208BLDOEN: PR173.1 PR174.1 PU11.7
SY8208BPG: PR110.1 PU11.2
SY8208BSW: PC213.2 PL21.1 PR180.2 PU11.10
SY8208BVOUT: PC204.1 PR188.1 PU11.4
SY8208CBST: PR175.2 PU12.6
SY8208CBST_S: PC200.1 PR175.1
SY8208CEN: PC211.2 PQ40.3 PR183.1 PR184.1 PR185.1 PU12.1
SY8208CFB: PR182.1 PU12.3
SY8208CSW: PC200.2 PL20.1 PR176.2 PU12.10
SY8208CVOUT: PC214.1 PR187.1 PU12.4
SYS_I: PC68.1 PR12.1 U11.68
SYS_RESET#: CN9.13 R551.1 U25.AC3
TD_IREF: R484.1 U25.B12
TEMP_MBAT: PC67.2 PR3.2 U11.70
TEST_A4: TP21.1 U25.A4
TEST_A60: TP26.1 U25.A60
TEST_A62: TP27.1 U25.A62
TEST_AV1: TP33.1 U25.AV1
TEST_AW1: TP32.1 U25.AW1
TEST_AW63: TP34.1 U25.AW63
TEST_AY60: TP36.1 U25.AY60
TEST_B2: TP22.1 U25.B2
THRM_ALERT_HW#1: Q16.1 R207.1 U11.80
THRM_MOINTOR1: C375.2 C376.2 R162.2 R280.1 U11.72
TP_SMB_CLK: C565.2 CN16.2 Q27.3 R403.1
TP_SMB_DATA: C561.2 CN16.1 Q27.6 R401.1
TPCLK: L38.1 R415.2 U11.85
TPCLK-1: C575.1 CN16.4 L38.2
TPDATA: L35.1 R412.2 U11.86
TPDATA-1: C572.1 CN16.5 L35.2
TPM_PP: R385.2 R392.1 U18.7
TPM_TESTB1: R365.1 U18.9
TRA_V_DAC: C115.1 U6.10 U6.15 U7.10 U7.15
TS_INTB#: CN2.15 EC3.2 R19.2
TS_INTB#_1: R523.1 U25.P4
TS_ON: Q7030.2 R19.1 U11.29
TSENSE: PC173.1 PR73.1 PU3.13
TST: R364.1 U15.14
TST2: R8517.1 U8021.14
UART0_CTS: RP5.3 U25.G1
UART0_RTS: RP5.2 U25.J2
UART0_RXD: RP5.9 U25.J1
UART0_TXD: RP6.6 U25.K3
UART1_CTS: RP5.8 U25.J4
UART1_RST: RP5.1 U25.J3
UART1_RXD: RP2.9 U25.K4
UART1_TXD: RP5.4 U25.G2
ULT_EDP_HPD: CN2.25 R483.1 R487.1 U25.D6
USB3_1+: C389.2 R305.2
USB3_1-: C391.2 R306.2
USB3_2+: C417.2 R322.2
USB3_2-: C420.2 R324.2
USB3_SSRX+: C8775.2 CN2.6 R8551.1
USB3_SSRX+_DC: C8775.1 U8021.9
USB3_SSRX-: C8774.2 CN2.5 R8550.1
USB3_SSRX-_DC: C8774.1 U8021.8
USB3_SSTX+: C8745.2 CN2.3 R8553.1
USB3_SSTX+_DC: C8745.1 U8021.12
USB3_SSTX-: C8786.2 CN2.2 R8552.1
USB3_SSTX-_DC: C8786.1 U8021.11
USB30_RX1+: R312.2 U25.H20
USB30_RX1+_C: CN25.6 R312.1
USB30_RX1+_DC: C8782.2 U8021.22
USB30_RX1+_L: R8547.1 R8551.2
USB30_RX1-: R314.2 U25.G20
USB30_RX1-_C: CN25.5 R314.1
USB30_RX1-_DC: C8746.2 U8021.23
USB30_RX1-_L: R8546.1 R8550.2
USB30_RX2+: R329.2 U25.F18
USB30_RX2+_C: CN28.6 R329.1
USB30_RX2-: R330.2 U25.E18
USB30_RX2-_C: CN28.5 R330.1
USB30_RX3+: C487.1 U25.F17
USB30_RX3+_C: C487.2 U15.22
USB30_RX3+_DC: CN14.26 U15.9
USB30_RX3-: C483.1 U25.G17
USB30_RX3-_C: C483.2 U15.23
USB30_RX3-_DC: CN14.25 U15.8
USB30_RX4+: C8782.1 R8547.2 U25.G15
USB30_RX4-: C8746.1 R8546.2 U25.F15
USB30_TX1+: C389.1 U25.B34
USB30_TX1+_C: CN25.9 R305.1
USB30_TX1+_DC: C8783.2 U8021.19
USB30_TX1+_L: R8548.1 R8553.2
USB30_TX1-: C391.1 U25.C33
USB30_TX1-_C: CN25.8 R306.1
USB30_TX1-_DC: C8785.2 U8021.20
USB30_TX1-_L: R8549.1 R8552.2
USB30_TX2+: C417.1 U25.A33
USB30_TX2+_C: CN28.9 R322.1
USB30_TX2-: C420.1 U25.B33
USB30_TX2-_C: CN28.8 R324.1
USB30_TX3+: C486.1 U25.C31
USB30_TX3+_C: C486.2 U15.19
USB30_TX3+_DC: C514.2 CN14.29
USB30_TX3+_DC_L: C514.1 U15.12
USB30_TX3-: C485.1 U25.C30
USB30_TX3-_C: C485.2 U15.20
USB30_TX3-_DC: C520.2 CN14.28
USB30_TX3-_DC_L: C520.1 U15.11
USB30_TX4+: C8783.1 R8548.2 U25.A31
USB30_TX4-: C8785.1 R8549.2 U25.B31
USB_BIAS: R193.1 U25.AJ10 U25.AJ11
USB_OC1#: R195.1 U25.AL3
USB_OC2#: R211.1 U25.AT1
USB_OC3#: R561.1 U25.AH2
USB_OC4#: R571.1 U25.AV3
USBP0+: R594.2 U10.3 U25.AM8
USBP0+_C: CN25.3 R310.1
USBP0+_CHA: R310.2 R594.1 U10.10
USBP0-: R587.2 U10.2 U25.AN8
USBP0-_C: CN25.2 R307.1
USBP0-_CHA: R307.2 R587.1 U10.11
USBP1+: L29.4 U25.AT7
USBP1+_C: CN14.23 L29.3
USBP1-: L29.1 U25.AR7
USBP1-_C: CN14.22 L29.2
USBP3+: L22.4 U25.AT10
USBP3+_C: CN11.6 L22.3
USBP3-: L22.1 U25.AR10
USBP3-_C: CN11.7 L22.2
USBP4+: R317.2 U25.AL15
USBP4+_C: C397.1 CN12.5 R317.1
USBP4-: R316.2 U25.AM15
USBP4-_C: C396.1 CN12.4 R316.1
USBP5+: L27.1 U25.AN13
USBP5+_C: CN28.3 L27.2
USBP5-: L27.4 U25.AM13
USBP5-_C: CN28.2 L27.3
USBP6+: CN22.38 U25.AN11
USBP6-: CN22.36 U25.AP11
USBP7+: L7.3 U25.AP13
USBP7+_C: CN2.14 L7.4
USBP7-: L7.2 U25.AR13
USBP7-_C: CN2.13 L7.1
USBPW_ON#: CN14.9 EC55.1 U11.125 U27.4
VADJ1: C40.1 C8742.1 CN2.22 R28.2 R440.2
VBOOT: PR163.1 PU3.14
VOLMUTE#: D11.1 D13.2 D14.2 U11.32
VR_HOT#: PR86.1 PU3.2
VR_RDY: PR76.1 PU3.6
VR_SVID_ALERT#: C718.2 PR82.2 R531.2 R533.2
VR_SVID_CLK: PR79.2 U25.N63
VR_SVID_DATA: PR84.2 R521.2 U25.L63
VREFOUT_C: C585.1 R430.1 U20.23
VRON: PR89.2 U11.83
WIRELESS_OFF: EC71.1 Q30.2 R414.2 U11.78
WIRELESS_OFF_R: CN13.2 Q30.3 R413.1 R414.1
WIRELESS_ON: EC56.1 Q28.2 R409.2 U11.76
WIRELESS_ON_R: CN13.3 Q28.3 R409.1 R422.1
XCLK_BIASREF: R149.2 U25.C26
XDP_BPM0: CN8.41 U25.J60
XDP_BPM1: CN8.42 U25.H60
XDP_DBRESET_N: C362.2 CN8.7 R263.1
XDP_PRDY#_CPU: CN8.33 U25.J62
XDP_PREQ#_CPU: CN8.32 U25.K62
XDP_RST: CN8.8 R262.2
XDP_TDI_CPU: R509.2 U12.6 U25.F63
XDP_TDO_CPU: R506.2 U12.3 U25.F62
XDP_TMS_CPU: R496.2 U12.8 U25.E61
XDP_TRST#: CN8.4 U12.12
XDP_TRST#_CPU: R580.2 U12.11 U25.AU62 U25.E59
XTAL1: R155.2 TP6.1 U8.28
XTAL2: C261.2 R159.1 U8.29 Y2.3
XTAL24_IN: C246.1 R147.1 R153.1 TP4.1 U25.A25 Y1.1
XTAL24_OUT: C245.1 R153.2 TP5.1 U25.B25 Y1.3
ZERO_ODD_DP#: ODD14.8 ODD15.8 R166.1 R553.1
ZERO_PWR_ODD: EC76.1 Q37.2 Q41.2 U11.2
N175071: PC59.1 PC60.1 PR96.2 PR100.1
N175281: PR89.1 PR91.1 PU3.1
N412685: PR71.2 PR73.2 PR162.1
N17144302: C533.2 Q25.2 Q26.3 R381.2
N17248901: C717.1 Q39.2 Q41.6 R497.1 R498.2
N17249052: Q41.3 R498.1
N17254457: C542.2 R391.1
N17254462: R376.2 U18.6
N17256569: Q20.2 Q21.3 R303.1 R315.2
N17259008: R309.2 U13.7
N17271649: CN29.2 CN29.4 R342.2
N17271663: CN29.70 CN29.72 CN29.74 R603.1
N17271713: CN29.10 TP13.1
N17271729: CN29.38 R601.2
N17276146: CN26.44 R318.2
N17345620: R369.1 U15.7
N17351782: C803.1 U28.17
N17351786: C804.2 U28.15 U28.16
N17351800: C799.1 U28.4
N17351802: C798.1 U28.2
N17351825: C803.2 U28.18
N17351895: C434.2 C439.1 R337.2
N17351898: C407.2 U14.17 U14.21
N17351904: C406.2 U14.22 U14.26
N17351907: C428.1 R326.2 R328.2
N17351912: R337.1 R341.1 R347.2
N17351914: R346.2 R354.1 U14.6
N17351950: C428.2 U14.11
N17351952: C439.2 U14.12
N17351965: R345.2 R353.1 U14.5
N17351980: C467.2 R355.1 U14.9
N17351981: C464.2 R343.1 R355.2 U14.10
N17352017: C460.2 R347.1
N17352037: C590.1 R423.1
N17352048: C593.1 R426.1
N17352052: R418.2 R419.2 U21.1
N17352055: R416.2 R417.2 U21.15
N17457344: R592.2 R597.2 U10.4
N17457353: R236.2 U10.15
N17457355: R596.2 U10.5
N17457385: R235.1 U10.16
N17457428: R595.1 U10.9
N17580566: R213.1 R227.1 U11.122
N17595064: C8739.1 H23.1 H23.2 R339.1
N17600271: PC216.2 PU12.5
N17605466: PC204.2 PR177.2
N17605675: PC214.2 PR182.2
N17644052: R291.1 R296.1 U11.48
N17644703: R274.1 R275.1 U10.6
N17679694: C355.2 C356.1 Q17.2 R257.2
N18045822: EC19.1 R124.1 R125.1 R127.1 R128.1
N18129791: R431.2 U20.30
N18283361: C798.2 R622.1
N18283364: C799.2 R623.1
N18673300: C8738.2 R604.2
N18680854: Q7030.3 R7465.1 R7466.2
N18680937: C7748.2 Q7031.2 R7465.2
N18773425: Q37.3 R532.2
N19250842: R156.1 U8.25
N19299291: R148.1 U25.C35
N19299303: R152.1 U25.C34
N19299315: R239.1 U25.AK8
N19299327: R245.1 U25.AL8
N19352741: Q24.1 R332.1 R333.1 R366.1 R367.1
N19395477: R7470.1 U14.14
N20069633: PD11.2 PR223.1
N20070129: PQ40.2 PR223.2 PR224.1
N20718638: PC250.2 PQ43.3 PQ44.3 PR247.2 PR248.1
N20718668: PQ41.3 PR237.2
N20722048: L8.2 U2.1
N20724765: R8515.1 U8021.7
N20796945: R7478.2 U22.3
N20796949: C1028.1 U22.4
N20797376: Q34.6 R7487.1 R8563.2
N20797384: Q820.3 Q820.6 Q821.3 Q821.6 R7479.1 R7482.2
N20797388: Q34.3 R7481.1 R8564.2
N20797417: Q820.2 Q820.5 R8564.1
N20797556: Q34.2 Q34.5 R7484.2
N20849527: R8558.1 R8559.1 U11.66
N20856073: C440.2 R336.1
N20880871: C540.2 R371.2
N21162142: Q821.2 Q821.5 R8563.1
N21181483: EC10.1 R91.1
N21244249: C365.1 R272.2
N21579333: C468.2 R349.1
N21693128: R407.2 U19.32
N21768474: C370.2 R276.1 R280.2
N21829998: D4.2 U11.108
N21834644: Q15.2 R221.1 R229.1
N21836538: C383.2 D8.2 R294.2 R298.1 R304.1
N21913817: PQ9.3 PR61.2
N22163425: R386.1 U16.4
N22190399: CN8.1 R270.1
N23232206: CN22.5 R94.1
N23234772: CN21.13 R439.2
N23234774: CN21.14 R454.1
N23235545: C608.2 R101.1 R119.1 R131.1 R140.1
N24212148: Q18.3 R257.1 R267.2
N26062304: PC206.2 PR180.1
N26069681: PC109.1 PU8.12
N26069683: PC111.1 PU8.10
N26069863: PC112.1 PR135.2 PU8.5
N26069874: PC108.1 PR124.1 PU8.3
N26073897: PC82.1 PU5.12
N26073915: PC86.1 PU5.10
N26074092: PC87.1 PR118.2 PU5.5
N26074102: PC80.1 PR113.1 PU5.3
N26154108: PR103.2 PU10.6
N26154172: PR108.1 PR109.2
N26154190: PR102.2 PU10.7
N26154214: PC71.2 PR106.1 PU4.1
N26154223: PC74.1 PR104.2 PU4.4
N26154319: PC184.2 PR168.1
N26154331: PR107.1 PU4.5
N27387581: R374.2 U17.3
N27387585: C548.1 U17.4
N27387907: C583.1 Q31.3 R432.2
N27595117: C586.1 C587.2 U20.25
N27595147: R411.1 U20.7
N27595159: C588.1 U20.21
N27595207: C571.1 C574.1 R436.1
N27595246: R429.1 U20.22
N27595457: C544.1 U20.1
N27595642: Q29.2 R408.1
N27595733: C563.2 U20.34
N28189735: C546.1 R388.2
N28189738: C545.1 R387.2
N33402405: PQ34.3 PR17.2
N33402410: PC233.1 PR16.2 PR17.1 PR213.1 PU1.6
N33402439: PR18.1 PR214.1 PU1.10
N33402467: PQ34.2 PQ35.3 PR20.2 PR21.2
N33402472: PQ38.6 PR206.2 PR207.1 PR209.2
N33402473: PQ38.5 PR209.1
N33402478: PQ38.1 PR208.1
N33402480: PQ38.2 PR207.2
N33402502: PC235.1 PR14.1
N33402505: PQ35.2 PR215.2 PR216.2
N33402710: PQ1.3 PR7.2
N33402820: PQ17.5 PQ18.3 PR64.1 PR66.2
N33402831: PQ17.3 PR63.1 PR68.1
N33402842: PQ17.6 PR64.2
N33402848: PQ14.3 PQ16.5 PR62.1 PR65.2
N33402861: PQ16.3 PR67.1 PR69.1
N33402863: PQ16.6 PR62.2
N34547300: PC106.1 PR126.2 PU7.4
N34547582: PC90.1 PR119.1
N34547691: PC217.2 PR186.1
N34551022: PR132.2 PU7.10
N34551161: PR123.1 PU7.3
N41915855: PC168.2 PR161.1
N41915908: PR75.2 PR159.1
N41916085: PC62.2 PR98.1 PR99.2
N41916105: PR85.2 PR90.2 PR160.2
N41916134: PC63.1 PR95.2
N41916242: PR164.2 PU3.16
N122990257: CN8.35 R288.2
N168403930: C357.1 U11.12
N172588423: TP12.1 U13.9
N212352420: PC199.2 PR176.1

Pads without a net: BAT14 5 11; BAT15 5; BAT17 12 21 22; CN2 11 18 21 26 29 40 41 42; CN3 5 6; CN5 7 8; CN6 3 4; CN9 16 17 18 19 20; CN10 5 6; CN11 1 9 10; CN12 7 8; CN13 33 34; CN14 31 32; CN16 7 8; CN17 5 6; CN22 3 30 32 42 45 47 49; CN24 13 14; CN26 1 3 5 7 8 10 11 12 13 14 16 17 19 20 22 30 32 36 38 42 45 46 47 49 51; CN29 5 6 7 8 9 11 12 13 14 15 16 17 18 19 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 56 58 67 68 76 77; CN31 5 6; HD17 11 12; JDIM1 77 122 125; JDIM2 77 122 125; NOREF#2 1; NOREF#3 1; NOREF#6 1; NOREF#7 1; NOREF#8 1; NOREF#10 1; U6 4 5 12 13; U7 4 5 12 13; U9 12; U10 13; U11 126; U13 2 3; U15 5 24; U18 1 2 3 8 12 13 14 15 28; U19 13 22 23 24 25 26 31; U20 14 15 16 17 18 19 20 24; U21 6 10; U25 A5 A6 A8 A21 A23 A37 A41 A49 A51 A53 AA23 AA59 AB21 AB23 AC2 AC4 AC20 AC58 AC59 AD2 AD4 AD23 AD59 AD60 AE6 AE59 AE60 AF2 AF4 AF20 AG4 AG58 AJ7 AL1 AL11 AL32 AM10 AM11 AN10 AP7 AP8 AP32 AR8 AT2 AU10 AU12 AU15 AU44 AU63 AV2 AV10 AV44 AV50 AV62 AV63 AW10 AW14 AW49 AY8 AY14 AY42 AY43 B5 B6 B21 B22 B23 B37 B41 B43 B49 B50 B51 B53 B54 C5 C17 C21 C42 C43 C46 C47 C49 C50 C51 C53 C62 C63 D1 D3 D9 D11 D15 D17 D58 D61 E1 E5 E6 E8 E13 E15 F5 F6 F8 F22 G10 H10 H18 H22 H61 H62 H63 J20 J21 J58 J61 K10 K18 K21 K59 K60 L8 L11 L59 L60 M20 M21 N23 N58 N59 N60 N61 P20 P60 P61 R20 R23 T23 T59 U10 U59 V21 V59 W23 Y4 Y20 Y22; U27 5; U8021 5 24

## Via types
v1: diameter 0.66, hole 0.33, TOP to BOTTOM, 697 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 3673 vias
v3: diameter 0.457, hole 0.254, TOP to BOTTOM, 56 vias
v4: diameter 0.66, hole 0.254, TOP to BOTTOM, 212 vias
v5: diameter 0.61, hole 0.356, TOP to BOTTOM, 449 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.05VMOD_OND: length 16.2
  TOP w0.508: PQ5.3 v2(176.81,128.96) 176.17,128.32 175.41,128.32 175.03,127.94 PR57.2 PR56.1
  BOTTOM w0.127: v2(177.03,119.66) 176.55,119.18 176.55,118.03 v1(176.56,117.87)
  BOTTOM w0.508: v2(177.03,119.66) 177.03,128.73 v2(176.81,128.96)
1.05VMOD_ONG: length 4.1
  TOP w0.127: v1(172.87,134.67) 172.87,133.78 173.58,133.07 173.58,132.56 PQ5.2
5V_HSMBCK: length 3.2
  TOP w0.127: v2(17.15,89.77) 17.81,89.11 R196.1 19.04,88.57 D3.1
5V_HSMBDT: length 2.5
  TOP w0.127: D5.1 18.79,86.67 v1(18.26,86.13) 17.81,86.58 R202.1
5VS5_ON: length 61.5
  TOP w0.127: v2(39.27,45.01) 39.27,44.16 37.45,42.34 32.79,42.34 v1(32.28,42.85) 31.65,43.49 31.65,50.85 33.81,53.01 33.81,55.04 v2(34.31,55.55) ; v2(44.88,65.28) 44.88,66.64 46.02,67.79 46.02,71.83 44.6,73.25 44.6,73.33 41.55,76.38 41.55,76.61 39.32,78.84 38.58,78.84 38.4,79.02 U11.128
  BOTTOM w0.127: v2(34.31,55.55) 34.77,56.01 34.77,62.11 37.36,64.7 37.36,64.93 37.75,65.33 38.25,65.33 39.55,66.62 43.54,66.62 v2(44.88,65.28) ; PR184.2 v2(39.27,45.01)
8008VFB1.5V: length 6.9
  TOP w0.127: PU4.6 188.83,62.61 189.15,62.28 PR105.2 189.63,62.04 189.89,61.77 190.58,61.77 191.22,61.14 PR108.2 192.29,60.63 193.57,60.63 v1(193.95,61.01)
81101VCC: length 6.8
  TOP w0.203: v2(95.34,81.07) 95.09,81.07 94.82,81.33 PU3.28
  TOP w0.254: v2(95.34,81.07) 96.55,81.07 v1(97.18,80.44) 97.31,80.32 97.31,79.05 97.77,79.05 97.86,79.15 PR97.1
  BOTTOM w0.381: PC61.2 v2(95.34,81.07)
81101VRMP: length 6
  TOP w0.127: PR74.1 98.12,88 v1(98.12,88.72)
  TOP w0.203: PR74.1 96.67,85.91 v2(96.67,85.4) 96.47,85.2 PU3.7
  BOTTOM w0.254: v2(96.67,85.4) 96.42,85.65 PC174.1
81101VSN: length 4.3
  TOP w0.203: PU3.26 94.02,80.7
  TOP w0.254: PC59.2 PR96.1 94.26,79.91 v1(94.54,80.19) 94.02,80.7
81101VSP: length 6.9
  TOP w0.203: 94.48,81.03 94.42,81.09 PU3.27
  TOP w0.254: 94.48,81.03 95.2,80.32 v1(95.83,80.32) 95.91,80.32 96.29,79.93 PC60.2 96.53,79.05 96.8,78.79 96.8,77.27 97.04,77.02 PR101.1
+0.65V_DDR_VTT:
  vias: v1(174.93,42.9) v2(95.78,41.07) v2(96.56,41.06) v2(173.47,31.27) v2(173.46,30.63) v2(174.22,44.02) v2(174.22,43.38) v2(174.22,42.72)
+1.5V: length 359.4
  TOP w0.381: v2(65.68,47.93) 65.95,48.19 C405.1
  TOP w0.508: v2(169.85,13.87) 169.85,13.29 R408.2 ; v2(121.23,23.34) 121.23,19.99 122.88,18.34 v2(122.88,15.11) ; v2(173.86,16.28) 174.49,16.28 L32.1 ; v2(77.62,50.81) 77.65,50.78 C400.1 ; v2(158.78,94.3) 158.78,94.84 159.29,95.35 R171.2 159.57,95.38 159.57,96.34 159.05,96.86 v2(159.05,97.71) ; v2(85.62,47.96) C403.1
  IN1 w0.508: v2(169.85,13.87) 169.85,14.22 170.97,15.34 171.33,15.34 172,16 173.58,16 v2(173.86,16.28) ; v2(159.05,97.71) 159.05,100.48 v2(159.12,100.55)
  IN2 w0.508: v5(177.9,67.11) 178,67.21 178,71.89 178.59,72.47 178.59,73.85 177.95,74.49 177.95,75.74 181.21,79 181.21,83.78 182.73,85.29 182.73,88.22 189.33,94.83 189.33,95.76 188.75,96.34 188.75,97.92 187.73,98.94 187.73,99.67 187.27,100.13 187.27,101.17 186.74,101.7 186.74,104.29 185.95,105.08 185.95,113.01 186.23,113.29 186.23,144.81 180.36,150.67 180.36,152.02 178.66,153.72 v2(178.33,153.72)
  IN2 w1.016: 167.51,73.76 173.26,68.01 173.26,60.59 174.5,59.35 174.5,57.71 175.46,56.74 175.46,47.51 178.83,44.14 178.83,42.96 177.44,41.57 177.44,35.69 175.06,33.3 175.06,33.26 174.65,32.86 174.65,31.77 174.65,31.77 174.65,29.1 174.65,29.1 174.65,28.36 174.27,27.97 174.27,27.97 173.13,26.83 168.53,26.83 165.44,23.73 153.66,23.73 153.65,23.74 123.05,23.74 122.65,23.34 v2(121.23,23.34) 120.74,23.34 120.34,23.74 112.77,23.74 102.04,34.47 100.51,34.47 97.76,37.21 95.71,37.21 92.45,40.46 91.39,40.46 89.83,42.02 89.83,44.64 88.34,46.13 88.34,47.19
  BOTTOM w0.254: v2(159.12,100.55) 159.34,100.55 U25.J15
  BOTTOM w0.508: v2(169.85,13.87) 169.75,13.97 168.85,13.97 168.48,14.34 168.48,15.1 167.65,15.93 163.07,15.93 162.59,16.41 161.8,16.41 146.1,16.41 145.84,16.15 144.41,14.72 123.28,14.72 v2(122.88,15.11) ; 188.57,158.59 188.57,158.55 188.49,158.47 188.49,158.44 188.2,158.15 CN22.28 ; 188.57,158.59 188.57,158.88 187.96,159.49 183.98,159.49 183.61,159.13 181.94,159.13 181.89,159.18 178.71,159.18 178.15,158.62 176.55,158.62 176.2,158.27 CN22.6 176.18,157.06 C647.1 C651.1 176.18,153.41 C652.1 176.95,153.01 177.01,153.01 v1(177.62,153.62) 177.72,153.72 v2(178.33,153.72) ; 188.57,158.59 192.54,158.59 193.72,159.77 195.48,159.77 196.2,159.04 CN22.48
  vias: v2(86.26,47.5) v2(174.97,67.25) v2(174.97,66.61)
+1.05V: length 234.4
  TOP w0.203: C322.1 70.51,85.14 70.91,84.74 70.91,83.87 70.4,83.36 U9.3
  TOP w0.254: C288.1 155.84,96.86 v2(155.86,96.87) 155.84,96.89 C281.2 ; C380.2 77.24,64.95 77.06,65.13 CN8.52 ; C361.1 77.06,74.77 CN8.9
  TOP w0.381: R184.2 153.66,92.01 v2(154.18,91.49) ; R210.2 114.95,84.65 C325.1 ; v2(117.23,97.71) 117.23,97.57 117.32,97.49 v2(119.43,97.49) ; v2(158.61,90.36) 158.75,90.5 158.75,92.08 158.44,92.38 C310.1 ; C294.1 160.81,95.96 v2(160.72,96.05) ; R229.2 56.04,82.34 v2(56.46,82.34) ; v2(160.15,100.61) 160.12,100.58 C273.2 ; PR81.1 v2(99.85,84.38) ; PR83.1 v2(99.85,83.36) ; C380.2 76.65,64.58 v2(76.6,64.62) ; PR78.1 v2(99.85,85.4)
  TOP w0.508: PR87.1 PC57.2 v2(101.88,81.33) ; v2(155.86,94.43) 155.79,94.5 C293.2 154.99,95.07 154.96,95.05 154.07,95.05 152.69,93.66 C306.1 C305.1 150.76,93.66 150.18,94.24 C304.1 C303.1 ; L16.2 141.78,93.4 141.95,93.4 v2(142.49,93.93) ; v2(158.15,100.62) 157.25,99.72 C274.1 ; 118.13,85.9 120.52,88.29 123.57,88.29 125.17,89.89 130.23,89.89 131.65,91.31 133.7,91.31 134.03,91.64 v2(134.03,92.05) ; v2(92.99,74.6) 92.99,73.73 94.53,72.19 104.93,72.19 v1(112.8,80.06) 115.72,82.98 ; C361.1 76.34,74.97 v2(76.23,75.08) 76.22,75.09 76.22,76.1 77.15,77.02 78.65,77.02 79.27,77.65 80.54,77.65 80.92,77.27 R264.1 ; C322.1 70.7,85.26 v2(71.18,85.74)
  IN1 w0.508: v2(92.99,74.6) 90.94,74.6 90.19,73.84 79.9,73.84 78.94,74.81 76.5,74.81 v2(76.23,75.08) ; v2(99.85,85.4) v2(99.85,84.38) v2(99.85,83.36) v2(101.88,81.33) v2(104.15,83.6)
  IN2 w0.381: v2(119.43,97.49) v2(121.53,97.49)
  IN2 w0.508: 140.45,90.79 134.91,90.79 134.03,91.66 v2(134.03,92.05)
  BOTTOM w0.254: R506.1 123.15,100.58 122.44,99.87 R509.1 121.95,99.6 121.72,99.37 120.19,99.37 119.43,98.6 v2(119.43,97.49) ; v2(160.15,100.61) 159.93,100.61 U25.H15 ; U25.AG16 158.97,90.72 v2(158.61,90.36) 158.54,90.36 158.46,90.43 158.2,90.7 U25.AG17 ; v2(158.15,100.62) 158.48,100.29 U25.J17 ; U25.AG13 160.6,90.72 v2(160.22,90.35) 159.85,90.72 U25.AG14 ; U25.J11 161.54,100.33 161.54,100.9 U25.H11
  BOTTOM w0.279: U25.N8 163.09,98.22 162.88,98.01 U25.P9
  BOTTOM w0.305: R496.1 120.97,103.23 120.22,103.23 119.73,102.74 119.73,102.3 117.33,99.9 117.33,97.82 v2(117.23,97.71) ; U25.W21 156.23,94.8 v2(155.86,94.43) 156.23,94.06 U25.AA21 ; U25.R21 156.23,97.24 v2(155.86,96.87) 156.23,96.5 U25.T21 ; U25.H11 161.46,100.94 161.11,101.3 v2(161.05,101.3) ; v2(160.72,96.05) 160.72,96.43 161.37,97.08 161.57,97.08 162.24,97.75 U25.P9
  BOTTOM w0.381: R521.1 123.38,97.51 123.01,97.51 122.46,96.96 R533.1 122.06,96.96 v2(121.53,97.49) 121.05,97.97 R522.2 ; v2(104.15,83.6) 108.1,83.6 113.87,89.37 113.87,91.94 R556.2 R557.2 116.08,91.94 117.14,93 117.14,97.57 117.23,97.66 v2(117.23,97.71)
  BOTTOM w0.508: v2(56.46,82.34) 59.85,85.74 v2(71.18,85.74) 72.92,83.99 72.92,80.19 74.45,78.66 74.45,76.86 v2(76.23,75.08) 76.23,73.45 78.2,71.48 78.2,66.98 76.81,65.58 76.81,64.84 v2(76.6,64.62) ; v2(158.91,114.83) 158.91,115.12 158.9,115.13 158.9,115.97 158.42,116.46 L46.2 ; v2(101.88,81.33) 101.88,79.68 99.85,77.65 96.04,77.65 v2(92.99,74.6)
  vias: v2(157.57,96.53) v2(163.52,91.08) v2(168.68,108.89) v2(168.93,108.26) v2(169.31,108.84) v2(169.57,108.26) v2(169.95,108.84) v2(170.2,108.26) v2(173.02,117.17) v2(173.08,89.13) v2(173.76,117.17) v2(174.5,117.17) v2(175.13,117.17) v5(172.41,89.4) v5(179.78,81.71) v5(179.78,80.9) v5(179.75,80.16) v5(179.75,79.43) v5(180.53,81.56) v5(180.53,80.82) v5(180.53,80.06) v5(180.53,79.3)
+1.05V_LAN: length 15.5
  TOP w0.127: v1(29.87,115.49) 29.18,116.18 v2(29.08,116.18)
  TOP w0.203: U8.30 23.48,114 23.76,113.72 C250.1 ; U8.3 26.43,116.42 26.73,116.12 C233.1 ; U8.8 25.65,118.42 C228.1 ; 19.11,116.42 U8.22
  TOP w0.381: v2(29.08,116.18) 29.02,116.12 C234.1 C233.1 ; v2(27.79,119.74) 27.79,120.18 C228.1
  TOP w0.508: C250.1 C259.1 v2(23.76,110.67)
  vias: v2(15.95,111.15) v2(15.92,110.46) v2(15.92,109.78) v2(16.81,116.56) v2(18.51,111.13) v2(18.51,110.24) v2(18.49,109.35)
+1.05V_LAN_REGOUT:
  vias: v1(20.34,114.48)
+1.05V_MODPHY: length 4.1
  BOTTOM w0.254: U25.M9 162.88,98.73 U25.L10 162.44,99.21 U25.K9 163,99.77 v2(163.45,99.77)
  BOTTOM w0.508: v2(163.35,117.17) 163.98,117.81 L45.1 L44.1
  vias: v1(166.65,117.4)
+1.05V_S2:
  vias: v1(180.36,75.46)
+1.05VS5: length 14.4
  TOP w0.508: R210.1 R201.1 116.46,87.3 v1(118.64,89.48) 120.47,91.31 v2(120.47,91.44)
  BOTTOM w0.508: v2(120.47,91.44) 120.47,91.68 121.05,92.25 R554.1 R547.1 121.05,94.02 121.31,94.29 122.71,94.29 123.34,93.65 R548.1
+1.35VSUS: length 103.7
  TOP w0.203: v2(96.7,42.52) 97.05,42.16 97.2,42.16 97.46,41.9 PU7.19
  TOP w0.381: R379.1 151.37,24.51 150.9,24.51 v2(150.77,24.64)
  TOP w0.508: PC93.1 96.24,42.98 v2(96.7,42.52) ; 119.4,39.55 R352.1
  IN1 w0.762: 103.25,57.43 102.23,57.43 100.76,55.96 95.2,55.96 93.37,54.12 93.37,45.85 v2(96.7,42.52)
  BOTTOM w0.178: v2(147.74,86.93) 147.82,86.93 U25.AN33
  BOTTOM w0.203: v2(138.67,85.65) 138.69,85.65 139.04,86 U25.AR48
  BOTTOM w0.254: U25.AJ37 145.44,90 v2(145.44,90.48) ; JDIM2.118 149.85,27.28 150.04,27.48 ; 149.44,90.46 U25.AJ31 ; 149.44,90.46 v2(149.44,90.51) ; 149.44,90.46 149.92,90.94 151.55,90.94 151.78,90.71 152.21,90.71 U25.AH26 ; v2(141.18,82.41) 141.18,82.47 U25.AY44 ; U25.AJ33 v2(148.14,90.51) ; v2(137.98,81.21) 137.98,81.83 137.51,82.3 137.51,82.78 U25.AY50 ; v2(144.35,82.46) 144.34,82.46 U25.AY40 ; v2(147.46,82.48) 147.06,82.88 U25.AY35 ; v2(141.55,87.01) 141.74,87.01 142.02,86.73 U25.AP43
  BOTTOM w0.305: JDIM1.105 145.95,49.23 v2(146.47,49.76) ; JDIM1.99 144.15,49.12
  BOTTOM w0.356: JDIM1.124 151.65,38.18 151.29,37.82 ; JDIM1.87 140.55,49.74 ; 136.95,49.14 JDIM1.75 ; JDIM1.111 147.75,48.94 v2(148.04,49.23) ; v2(144.07,35.87) 144.15,35.78 JDIM2.99 ; v2(144.45,24.64) 144.45,24.64 JDIM2.100 ; JDIM1.100 144.45,37.97 v2(144.27,37.78) ; JDIM2.117 149.55,35.71 ; 139.72,35.68 v2(139.73,35.69) 140.25,35.69 140.55,35.39 JDIM2.87 ; 149.85,37.93 JDIM1.118 ; JDIM2.105 145.95,35.57 145.92,35.6 v2(146.02,35.7) ; v2(140.84,24.64) 140.85,24.65 JDIM2.88 ; v2(139.04,24.64) 139.05,24.65 JDIM2.82 ; v2(137.25,24.64) JDIM2.76 ; 139.05,38.19 JDIM1.82 ; JDIM1.93 142.35,48.82 ; v2(141.91,37.92) 141.14,37.92 140.85,38.21 JDIM1.88 ; v2(145.69,24.64) 145.9,24.64 146.25,24.99 JDIM2.106 ; v2(148,24.64) 148.05,24.68 JDIM2.112 ; 146.25,37.81 JDIM1.106 ; JDIM2.93 142.35,35.72 v2(142.37,35.74) ; 136.95,35.97 JDIM2.75 ; JDIM2.123 151.35,35.69 ; 138.75,49.16 JDIM1.81 ; 148.05,37.96 JDIM1.112 ; v2(142.67,24.64) 142.65,24.66 JDIM2.94 ; JDIM2.81 138.75,35.55 ; JDIM2.111 147.75,35.75 ; JDIM1.123 151.35,48.95 151.21,49.08 v2(150.99,49.08) ; 137.25,37.75 JDIM1.76 ; JDIM1.94 142.65,38.11 ; 149.55,49.15 JDIM1.117
  BOTTOM w0.381: 151.65,24.68 JDIM2.124 151.65,27.16 151.34,27.48 150.04,27.48
  vias: v1(132.48,39.04) v1(140.1,73.2) v2(111.15,49.33) v2(134.62,51.96) v2(134.62,51.33) v2(134.62,50.69) v2(134.62,50.06) v2(134.62,49.42) v2(136.5,24.64) v2(138.83,77.29) v2(138.83,76.66) v2(138.83,76.02) v2(138.83,75.39) v2(139.7,38) v2(142.46,51.73) v2(142.46,51.05) v2(142.46,50.36) v2(142.46,49.67) v2(143.03,77.52) v2(143.03,76.89) v2(143.03,76.25) v2(143.03,75.62) v2(146.44,51.49) v2(147.48,75.12) v2(148.04,49.99) v2(148.07,51.44) v2(148.06,50.75) v2(150.99,49.73) v5(103.91,58.47) v5(104.57,59.64) v5(104.57,58.88) v5(104.59,58.11) v5(105.33,58.88) v5(105.33,58.14) v5(105.36,59.61) v5(105.52,57.2) v5(105.52,56.46) v5(105.51,55.73) v5(110.26,51.49) v5(110.26,50.72) v5(110.41,60.12) v5(110.41,59.36) v5(110.39,58.6) v5(111.02,51.87) v5(111.02,51.11) v5(111.02,50.34) v5(111.15,60.12) v5(111.15,59.36) v5(111.15,58.6)
+1.35VSUS_S:
  vias: v1(103.27,48.31) v5(102.06,55.6) v5(102.06,54.84) v5(102.08,46.15) v5(102.08,45.39) v5(102.08,44.63) v5(102.84,46.15) v5(102.84,45.39) v5(102.84,44.63) v5(103.6,46.15) v5(103.6,45.39) v5(103.6,44.63) v5(103.91,53.49) v5(103.91,52.73) v5(104.67,53.44) v5(104.67,52.71)
+3.3VS5_S:
  vias: v1(59.84,38.66)
+3V: length 824.6
  TOP w0.178: C570.1 61.78,14.81 U19.27 ; U11.11 35.92,74.13 35.79,74.27 35.79,76.71 35.23,77.27 C350.1
  TOP w0.203: U19.11 62.98,21.09
  TOP w0.254: Q27.5 162.61,20.88 163.02,20.47 v2(163.02,20.27) ; v2(158.72,20.73) 158.8,20.73 158.95,20.88 Q27.2 ; CN14.17 197.8,23.25 197.34,22.79 C530.1 ; R535.2 183.08,105.19 RP2.10 183.08,107.19 ; RP2.5 180.54,107.45 180.8,107.19 183.08,107.19 ; 183.08,107.19 183.92,107.19 R139.2 ; R185.1 178.98,90.97 179.25,90.7 Q12.5 Q12.2 ; Q14.5 v2(27.56,87.78) ; Q14.2 v2(23.26,87.78)
  TOP w0.279: U18.5 76.45,22.5 ; U18.24 84.58,22.5 ; 85.37,18.97 85.08,19.25 U18.19 ; U12.14 88.87,68.78 ; U18.10 76.5,19.25
  TOP w0.305: v2(51.38,90.85) 51.38,90.68 51.59,90.48 R191.1 ; U8021.13 60.6,169.07 60.02,169.65 v2(59.92,169.65) 59.92,169.96 C8781.2 ; C8784.2 66.98,165.33 65.74,166.57 U8021.1
  TOP w0.381: R321.2 174.01,47.81 C408.1 173.51,48.54 v2(174.03,49.06) ; R203.1 R197.1 37.61,88.91 37.01,89.51 v2(37.01,91.57) ; v2(189.88,92.05) 190.35,92.52 R181.1 ; L37.1 173.89,12.76 C576.1 ; PR77.2 v2(101.85,86.41) ; R1.1 41.55,164.39 v2(41.3,164.14) ; R344.1 183.28,36.2 183.53,36.44 v2(183.53,36.46) ; R535.2 182.95,104.42 181.2,102.68 181.2,101.24 181.71,100.73 v2(181.94,100.73) ; v2(17.7,121.62) 17.79,121.52 18.39,121.52 R144.1 ; C125.2 161.3,97.85 C282.2 160.68,98.1 160.26,98.51 v2(159.98,98.51) ; 88.87,68.78 88.87,68.43 89.05,68.25 89.05,67.11 88.67,66.73 C378.2 88.42,65.85 88.1,65.52 88.1,64.25 88.1,64.25 v2(88.1,64.06) ; R194.1 181.01,88.83 180.55,88.38 v2(180.47,88.38) 179.87,88.38 178.93,89.32 178.69,89.32 178.31,89.7 178.31,90.87 R185.1 ; v2(168.96,13.26) 168.83,13.39 R627.1
  TOP w0.406: CN13.1 41.04,14.5 ; CN13.6 41.25,19.5
  TOP w0.508: C530.1 197.84,22.53 v2(197.99,22.68) ; R188.1 v2(26.41,91.26) ; v2(57.33,67.74) 56.93,67.74 R285.1 ; v2(32.73,92.61) 33.68,91.66 R189.2 ; R602.2 91.34,24.41 v2(91.26,24.33) ; v2(85.04,18.39) 85.25,18.17 85.83,18.17 C557.2 85.37,18.97 ; R8513.2 R8518.2 R8519.2 R8512.2 R8517.2 58.08,170.02 58.86,170.8 C8781.2 59.59,171.75 R58.1 R40.1 ; v2(38.05,59.59) 38.05,59.31 37.37,58.63 C463.2 CN12.6 ; v2(173.99,13.73) 173.99,13.4 C576.1 ; v2(174.39,15.37) 174.59,15.37 L33.1 ; v2(37.13,85.09) 37.72,84.51 R216.1 ; v2(91.84,21.21) 91.84,21.77 91.57,22.05 EC37.2 91.21,21.92 v2(91.21,21.23) ; v2(79.48,76.38) 79.91,75.95 R263.2 ; R187.1 v2(24.76,91.24) ; 41.25,19.5 v2(41.86,19.5) 42.24,19.13 42.24,15.7 41.04,14.5 ; v2(68.21,170.82) R8514.2 R8521.2 R8520.2 R8516.2 68.21,166.29 68.06,166.14 68.05,166.14 67.87,165.96 67.81,165.96 67.59,165.74 67.58,165.74 67.43,165.58 C8784.2 ; v2(174.1,36.33) 174.3,36.53 174.3,38.37 174.15,38.52 C444.1 C437.1 175.17,39.93 R334.1 ; v2(79.65,81.84) 79.65,80.66 77.66,78.67 76.44,78.67 74.53,76.76 71.91,76.76 71.27,76.12 71.27,75.49 70.86,75.08 66.44,75.08 65.51,74.15 65.51,66.48 v2(64.04,65.02) 64.04,55.92 65.05,54.92 v1(65.05,52.63) 65.05,51.74 v2(64.36,51.05) 64.03,50.72 C402.1 ; v2(181.67,155.24) 184.26,155.24 186.29,153.21 C8776.1 CN31.4 ; R376.1 73.66,22.28 72.97,21.59 72.97,20.78 73.51,20.24 R392.2 C554.2 74.31,18.73 74.7,18.34 75.59,18.34 76.5,19.25 ; v2(181.89,88.7) 181.51,88.7 181.13,89.08 R194.1 ; C524.2 75.88,22.5 76.45,22.5 ; v2(63.4,13.13) 62.38,13.13 R406.2 62.14,13.13 C573.1 C570.1 ; v2(86.82,47.99) 86.82,49.14 C404.1 ; C399.1 74.84,50.81 75.46,51.44 v2(75.46,51.87) ; v2(55.22,73.47) 55.19,73.44 R8554.1 ; 84.58,22.5 85,22.5 85.99,23.5 C523.2 85.97,23.7 v2(85.29,23.7) ; R260.1 32.39,77.07 32.04,76.72 v2(32.04,76.48) ; R179.2 160.31,94.08 v2(160.35,94.08) ; R386.2 109.49,20.88 107.61,20.88 107.08,21.4 107.08,22.15 v5(106.32,22.91) ; v2(35.2,76.63) 34.7,77.13 C350.1
  IN1 w0.178: 167.27,97.25 163.99,97.25 v2(163.53,96.8) 164.01,96.32
  IN1 w0.229: 164.01,96.32 165.66,96.32 166.04,95.94 167.17,95.94 167.44,96.2 167.44,97.08 167.27,97.25
  IN1 w0.381: v2(174.39,15.37) 174.32,15.29 173.76,15.29 173.68,15.21 172.39,15.21 171.55,14.38 171.52,14.38 171.28,14.14 171.28,13.63 170.95,13.3 169,13.3 v2(168.96,13.26) ; v2(181.67,155.24) 180.85,155.24 179.75,156.35 168.62,156.35 165.83,153.57 165.83,130.82 168.21,128.45 168.21,121.66 v2(166.08,119.52)
  IN1 w0.457: 167.27,97.25 167.69,97.67 167.69,98.34 168.04,98.69 168.72,98.69 171.04,101.02 v2(172.57,101.02) 173.96,99.62 v2(173.96,99.26)
  IN1 w0.508: v2(201.95,36.53) 203.48,35 203.48,26.09 201.83,24.44 199.77,24.44 198.02,22.68 ; v2(163.51,95.84) 163.16,95.84 162.63,95.3 161.06,95.3 160.35,94.59 v2(160.35,94.08) ; v2(37.13,85.09) 34.03,85.09 v2(33.26,84.32) ; v2(197.99,22.68) 198.02,22.68 ; 198.02,22.68 198.75,21.95 200.96,21.95 201.9,21.01 v2(201.9,15.14) ; 79.78,26.1 80.34,26.1 82.01,24.44 85.62,24.44 86.26,23.8 87.78,23.8 87.93,23.65 89.08,23.65 89.69,23.04 ; v2(51.38,90.85) 51.28,90.75 38.28,90.75 37.46,91.57 v2(37.01,91.57) 33.77,91.57 v2(32.73,92.61) ; v2(174.39,15.37) 174.39,14.4 173.99,14 v2(173.99,13.73)
  IN1 w1.016: 89.44,21.67 89.18,21.92 88.34,21.92 88.05,22.21 84.04,22.21 83.72,22.53 79.71,22.53 78.45,23.79 78.45,24.78 79.78,26.1
  IN1 w1.524: 79.78,26.1 79.78,28.14 77.29,30.63
  IN2 w0.381: 185.37,83.36 185.37,87.36 188.73,90.73 189.23,90.73 189.88,91.38 v2(189.88,92.05)
  IN2 w0.508: v2(163.51,95.84) 163.51,96.78 v2(163.53,96.8) ; v2(79.65,81.84) 79.9,82.09 95.15,82.09 99.46,86.41 v2(101.85,86.41) 101.85,87.07 97.69,91.24 97.69,104.41 103.21,109.93 106.39,109.93 106.43,109.98 108.68,109.98 110.07,111.37 110.07,113.27 111,114.2 117.12,114.2 117.96,115.04 120.41,117.49 134.16,117.49 v2(134.26,117.6) 138.78,117.6 140.36,119.18 156.87,119.18 157.96,120.27 157.96,121.03 158.44,121.51 160.37,121.51 162.15,119.74 165.86,119.74 v2(166.08,119.52) ; v2(38.05,59.59) 38.05,60.12 35.63,62.54 33.55,62.54 32.75,63.34 32.75,74.63 32.55,74.83 32.55,76.07 32.14,76.48 v2(32.04,76.48) 31.39,77.13 31.39,82.45 v2(33.26,84.32) 33.26,85.62 32.73,86.16 v2(32.73,92.61) 31.08,94.26 v2(21.44,94.26) ; v2(88.1,64.06) 88.1,64 87.7,63.6 85.7,63.6 85.24,64.06 83.97,64.06 82.07,62.15 82.07,57.46 82.85,56.67 v2(82.85,56.19) ; v2(55.22,73.47) 56.34,72.35 56.34,68.73 v2(57.33,67.74) ; 167.37,20.89 v2(168.81,19.46)
  IN2 w1.27: 180.67,34.52 179.22,33.07 179.22,29.38 177.39,27.55 177.39,27.26 174.25,24.12 170.91,24.12 167.68,20.89 167.37,20.89
  IN2 w2.54: 32.13,129.26 32.66,128.73 32.66,107.04 29.23,103.61 22.4,103.61 19.4,100.61 19.4,97.51
  BOTTOM w0.254: 178.81,102.67 178.84,102.64 RP6.10 ; 178.81,102.67 181.25,102.67 181.38,102.79 ; 178.81,102.67 177.75,102.67 ; 181.38,102.79 RP6.5 181.38,103.94 180.81,104.51 180.53,104.51 179.74,105.31 R493.2 ; 181.38,102.79 181.52,102.66 182.32,102.66 R499.2 ; U25.K16 U25.K14 160.07,98.6 v2(159.98,98.51) ; R486.2 167.63,115.12 167.01,115.74 166.45,115.74 166.11,116.08 166.11,119.49 v2(166.08,119.52) ; 177.75,102.67 175.54,102.67 175.16,102.29 RP5.10 ; 177.75,102.67 177.7,102.72 177.7,103.52 ; R529.2 182.77,97.72 183.09,97.4 184.06,97.4 Q38.2 Q38.5 ; U25.T9 v2(163.53,96.8) ; U25.W9 162.88,94.96 163.29,95.37 U25.V8 163.51,95.55 v2(163.51,95.84)
  BOTTOM w0.305: U25.U8 163.33,96.59 v2(163.53,96.8)
  BOTTOM w0.381: R536.2 176.67,96.31 177.45,97.09 ; v2(20.7,94.26) 20.43,94.53 20.43,108 20.05,108.38 16.28,108.38 15.34,109.32 15.34,119.44 17.51,121.62 v2(17.7,121.62) ; R523.2 173.55,98.22 v2(173.92,97.85) 174.18,97.59 R524.2 ; R551.2 R550.2 175.77,93.53 175.37,93.93 175.37,93.95 R546.2 R552.2 ; R551.2 177.45,93.54 177.45,94.67 R544.2 ; R551.2 177.66,93.53 179.28,91.92 179.28,91.21 180.47,90.02 v2(180.47,88.38) ; JDIM1.199 174.15,48.94 v2(174.03,49.06) ; v2(174.1,36.33) 174.25,36.17 174.25,35.34 174.15,35.24 JDIM2.199 ; R534.2 173.58,97.08 174.01,96.65 v2(174.01,96.43) 174.03,96.44 R158.2 ; v2(181.94,100.73) 182.11,100.73 182.69,101.31 182.69,102.29 R499.2 ; R519.2 174.24,98.98 v2(173.96,99.26) 173.86,99.37 R518.2 ; v2(33.26,84.32) 33.26,83.39 36.06,80.59 36.06,77.49 v2(35.2,76.63) ; R510.2 173.13,100.54 172.73,100.95 172.63,100.95 v2(172.57,101.02) ; R538.2 172.23,96.06 172.18,96.11 v2(171.75,96.11)
  BOTTOM w0.508: v2(79.48,76.38) 79.48,81.67 v2(79.65,81.84) ; R515.2 R516.2 183.61,99.88 184.2,99.29 186.36,99.29 187.73,97.91 R530.2 187.92,97.72 188.44,97.2 188.44,96.27 187.59,95.42 v2(187.59,94.78) ; R515.2 182.4,100.17 181.94,100.63 v2(181.94,100.73) ; R515.2 R514.2 R513.2 R512.2 179.21,99.87 R511.2 178.06,99.37 177.71,99.02 R520.2 ; 194.46,46.41 195.16,45.71 199.26,45.71 201.57,43.39 201.57,36.91 v2(201.95,36.53) ; CN26.52 87.25,48.21 87.03,47.99 v2(86.82,47.99) ; 177.45,97.09 R525.2 177.45,97.98 177.7,98.22 177.7,98.47 R520.2 ; v2(168.81,19.46) 169.47,19.46 173.56,15.37 v2(174.39,15.37) ; v2(201.9,15.14) 201.55,14.78 R613.1 ; v2(110.41,23.6) 109.73,22.91 v5(106.32,22.91) ; R482.2 134.37,114.85 133.88,115.34 133.88,117.21 v2(134.26,117.6) ; R520.2 178.33,98.48 v2(178.52,98.67) 178.64,98.55 178.64,98.02 178.93,97.72 R526.1 179.22,97.72 R527.2 R528.2 R529.2 ; v2(159.98,98.51) 160.31,98.51 160.73,98.09 160.73,97.38 160.08,96.73 160.08,94.35 v2(160.35,94.08) ; CN26.24 76.05,51.28 v2(75.46,51.87) 74.83,51.23 64.54,51.23 v2(64.36,51.05) 64.36,50.79 64.05,50.48 CN26.2 ; v2(57.33,67.74) 57.76,67.74 59.25,66.24 62.53,66.24 63.76,65.02 v2(64.04,65.02) ; CN26.41 v2(82.85,56.19) ; CN26.39 v2(82.05,56.19)
  vias: v1(62.99,24.31) v1(83.72,56.06) v2(16.03,71.25) v2(16.66,71.25) v2(43.51,178.16) v2(43.97,177.42) v2(52.6,180.52) v2(53.24,180.52) v2(54.1,180.04) v2(54.1,179.4) v2(61.47,27.1) v2(61.93,26.66) v2(62.36,26.14) v2(84,39.65) v2(84.71,39.62) v2(173.87,55.4) v2(173.9,54.76) v2(173.9,54.13) v2(181.9,50.57) v2(181.9,49.91) v5(47.8,15.62) v5(48.56,15.62) v5(49.33,15.62) v5(50.09,15.62) v5(50.9,15.62) v5(73.63,33.38) v5(73.81,34.14) v5(73.91,32.69) v5(74.51,33.54) v5(74.67,32.64) v5(74.98,24.94) v5(75.19,33.25) v5(75.16,24.13) v5(75.49,25.5) v5(75.64,32.66) v5(75.77,24.82) v5(75.77,23.6) v5(76.25,24.16) v5(105.43,22.91) v5(105.43,22.15) v5(182.24,74.5) v5(182.19,73.71) v5(183.97,82.19)
+3V_AON: length 5.2
  TOP w0.203: 69.59,79.51 69.6,79.52 U9.11
  TOP w0.381: C352.1 70.79,76.76 v1(70.81,76.78) 70.81,77.39 69.95,78.26 69.95,78.71 69.59,79.07 69.59,79.51
+3V_DEEP_SUS: length 177.5
  TOP w0.381: v2(157.92,94.56) 157.99,94.5 C301.2 157.99,93.24 157.72,92.97 156.02,92.97 154.84,94.16 154.07,94.16 153.06,93.14 153.06,92.56 152.32,91.82 147.93,91.82 147.5,91.39 143.31,91.39 142.39,90.47 131.62,90.47 128.95,87.81 127.33,87.81 126.92,87.4 124.89,87.4 124.65,87.64 121.53,87.64 117.17,83.27 117.17,78.59 v1(116.23,77.65) 104.93,66.35 104.93,62.61 101.42,59.11 v2(98.83,59.11) ; 173,71.68 172.57,72.11 172.57,76.11 172.11,76.56 171.33,76.56 170.81,77.08 170.81,77.52 170.94,77.64 v2(170.94,78.77) ; R163.2 185.44,101.19 v2(184.92,100.66) ; R211.2 180.48,85.13 v2(180.72,84.89) 181.11,84.89 181.37,84.64 R218.2 ; R8560.2 186.71,100.54 v2(186.61,100.64) 186.71,100.74 R164.2
  TOP w0.457: v2(184.92,100.66) 184.92,100.04 182.46,97.59 178.22,97.59 v2(178.11,97.47) 175.17,97.47 174.17,98.48 172.54,98.48 171.45,97.38 170.79,97.38 170.28,96.88 v2(170.28,95.86)
  TOP w0.508: R290.2 80.35,63.8 80.73,64.17 84.67,64.17 85.56,63.28 85.56,60.95 85.24,60.63 v2(84.86,60.63) ; v2(161.31,93.14) 161.19,93.02 161.19,92.15 161.06,92.02 161.06,90.37 v2(161.04,90.35) ; R180.2 184.29,92.29 184,92 v2(184,91.74) ; v2(161.79,80.57) 162.83,79.53 R238.1 162.99,78.89 162.99,77.74 164.73,76 R255.2 ; v2(187.11,94.3) 186.93,94.49 R172.2
  IN1 w0.381: v2(84.86,60.63) 86.64,60.63 86.97,60.31 92.28,60.31 93.67,61.7 94.11,61.7 96.7,59.11 v2(98.83,59.11)
  IN2 w0.508: v2(161.04,90.35) 161.04,89.49 160.09,88.54 160.09,85.29 161.14,84.25 161.14,81.22 v2(161.79,80.57)
  BOTTOM w0.254: v2(161.04,90.35) 161.14,90.35 U25.AH11 ; v2(157.92,94.56) 157.92,93.36 156.73,92.18 U25.AE20 156.33,91.59 U25.AE21 ; v2(163.51,94.89) 163.33,94.71 U25.Y8 163.22,94.41 162.88,94.08 U25.AA9 U25.AC9 162.85,93.02 162.17,93.02 162.04,93.14 v2(161.31,93.14)
  BOTTOM w0.381: v2(170.94,78.77) 170.94,78.69 171.36,78.27 R588.2 ; R574.1 162.25,78.6 162.25,80.1 v2(161.79,80.57)
  BOTTOM w0.508: v2(178.11,97.47) 178.11,96.29 178.83,95.56 R539.2 R540.2 R541.2 ; v2(184.92,100.66) 184.55,101.02 R503.2
  vias: v2(178.71,88.7) v2(180.24,87.43)
+3V_DVDD: length 16.5
  TOP w0.305: C578.1 178.63,11.53 179.58,11.53 v2(179.68,11.43) 179.73,11.43 180.31,12.01 U20.9
  TOP w0.381: v2(170.43,9.6) 170.43,11.35 170.75,11.68 R421.2 ; C578.1 177.95,11.24 177.74,11.03 175.69,11.03 C581.1 174.81,10.84 L37.2
  TOP w0.508: v2(173.89,9.92) L37.2
  BOTTOM w0.508: v2(173.89,9.92) 173.54,9.92 171.93,8.3 170.77,8.3 170.43,8.64 v2(170.43,9.6)
+3V_DVDD-IO: length 7.4
  TOP w0.305: C564.1 178.92,16.47 179.4,15.99 179.4,15.71 v2(179.73,15.39) 180.1,15.01 U20.3
  TOP w0.508: C564.1 178.56,16.76 177.64,16.76 C560.1 176.33,17.35 L32.2 L33.2
+3V_ECACC: length 11.3
  TOP w0.127: U11.74 53.48,69.33 55.51,71.36 57.62,71.36 58.13,71.87 v1(58.13,73.08) 58.05,73.15 C366.2 C363.1 58.05,75.65 57.96,75.74 L18.1
+3V_RTC: length 254.1
  TOP w0.203: U9.14 70.8,80 71.14,79.65 71.14,79.27 70.86,78.99 v1(70.86,78.74)
  TOP w0.381: v1(70.86,78.74) 71.42,78.74 71.48,78.8 C344.2 v2(72.42,78.8)
  TOP w0.508: v2(167.8,76.85) 167.5,76.85 166.89,76.24 R256.1 166.89,75.87 166,74.98 C364.1 C368.1 C371.1 ; C371.1 165.64,72.09 v1(165.5,71.96) 165.5,70.65 171.35,64.81 171.35,61.39 172.32,60.42 173.95,60.42 v2(174.32,60.78) 174.34,60.81 174.34,62.24 174.72,62.61 176.86,62.61 177.57,61.9 179.09,61.9 179.6,61.39 179.6,60.25 180.11,59.74 181,59.74 182.01,60.76 182.4,60.76 182.78,61.14 186.9,61.14 187.95,60.1 189.41,60.1 C388.1 190.51,59.37 191.29,58.6 D9.3 ; C371.1 166.9,72.95 167.03,73.08 R277.1
  IN2 w0.508: v2(174.32,60.78) 175.39,59.72 175.39,58.09 176.35,57.12 176.35,47.88 179.72,44.51 179.72,42.59 178.57,41.45 178.57,35.52 175.54,32.49 175.54,31.4 175.54,31.4 175.54,29.47 175.54,29.46 175.54,27.99 175.16,27.6 175.16,27.6 173.5,25.94 168.9,25.94 165.81,22.84 153.29,22.84 153.28,22.85 123.46,22.85 123.06,22.45 120.11,22.45 119.72,22.85 112.4,22.85 101.67,33.58 100,33.58 97.38,36.2 95.32,36.2 92.02,39.5 90.8,39.5 88.7,41.61 88.7,43.98 83.46,49.22 83.46,52.04 79.64,55.87 79.64,58.49 73.91,64.22 69.05,64.22 68.31,64.95 68.31,67.03 67.69,67.65 67.69,69.71 67.82,69.84 67.82,76.41 69.87,78.46 72.08,78.46 v2(72.42,78.8) ; v2(167.8,76.85) 167.22,76.85 163.86,80.21 163.86,82.21 161.98,84.09 161.98,87.6
  BOTTOM w0.305: U25.AG10 162.22,90.72 v2(161.85,90.35)
  BOTTOM w0.508: R575.1 R576.2 R577.1 167.69,76.85 v2(167.8,76.85)
+3V_RTC_0: length 206.9
  TOP w0.508: v2(66.67,75.74) 66.27,75.74 65.84,76.17 v1(65.84,76.76) 65.85,76.74 66.93,76.74 R252.1 ; R302.1 195.35,58.75 v2(194.99,58.39)
  IN2 w0.508: v2(183.01,54.39) 182.55,53.93 182.55,46.82 183.19,46.18 183.19,40.3 184.57,38.91 184.57,36.59 183.8,35.81 183.4,35.81 183.1,35.51 180.34,32.76 180.34,29.07 178.4,27.12 178.4,26.84 173.98,22.41 173.52,22.41 169.14,18.03 166.6,18.03 165.05,16.48 163.68,16.48 163.67,16.49 163.62,16.49 162.6,17.5 160.33,17.5 159.38,18.44 155.21,18.44 154.83,18.82 104.9,18.82 103.38,20.35 103.38,28.14 99.99,31.52 99.16,31.52 98.62,32.06 96.04,32.06 93.04,35.05 93.04,35.76 91.71,37.08 90.3,37.08 87.15,40.23 87.15,43.82 81.28,49.68 81.28,51.84 75.83,57.29 75.83,58.64 71.08,63.39 69.53,63.39 69.49,63.42 68.4,63.42 66.7,65.13 66.7,69.98 66.52,70.16 66.52,70.89 66.7,71.07 66.7,75.72 v2(66.67,75.74)
  BOTTOM w0.508: v2(183.01,54.39) 183.01,54.37 184.24,53.14 192.17,53.14 193.95,54.92 193.95,58.34 193.7,58.6
+3V_RTC_1: length 3.2
  TOP w0.127: R302.2 195.35,59.84 v1(196.19,60.68)
  TOP w0.508: D9.1 194.11,59.75 R302.2
+3V_RTC_R: length 5.7
  TOP w0.127: v1(68.15,75.8) 67.98,75.8 67.72,76.06 R252.2
  TOP w0.203: C347.1 69.2,78.78 U9.10
  TOP w0.508: C347.1 69.11,77.9 67.97,76.76 R252.2
+3V_S2: length 1.9
  TOP w0.127: PC101.1 68.32,35.37 v1(68.32,35.99)
+3V_VSTBY: length 8.6
  TOP w0.178: U11.127 38.8,80.58 38.66,80.72 37.39,80.72 v1(37.23,80.57) 36.59,81.21 C334.2
  TOP w0.381: L17.1 34.72,84.02 35.14,83.6 35.14,82.46 36.02,81.59 C334.2
+3V_WLAN_P: length 46
  TOP w0.508: v2(193.13,55.33) 195.39,55.33 198.21,58.15 199.65,58.15 200.46,58.95 200.46,67.97 198.84,69.58 198.33,69.58 195.27,72.64 v1(195.27,76.76) 195.27,78.49
  BOTTOM w0.508: v2(193.13,55.33) 191.7,53.9 184.94,53.9 183.03,55.8 183.03,59.44 v2(183.08,59.49)
  vias: v2(173.25,157.91) v2(173.89,157.91) v2(185.55,160.39) v2(186.23,160.39) v2(186.59,158.7) v2(192.68,80.77) v2(193.7,80.77) v2(194.46,85.04)
+3VCARD: length 0.8
  TOP w0.203: 62.43,21.01 62.58,20.86 U19.12
  vias: v1(53.44,20.96) v2(35.66,23.16) v2(36.29,23.16) v2(61.59,21.74) v2(62.18,21.44)
+3VLANVCC: length 196.8
  TOP w0.203: 24.66,114.22 24.28,114.6 U8.32 ; C323.1 71.3,84.78 71.3,83.77 70.8,83.27 U9.2 ; C227.1 23.48,119.79 U8.11 ; U8.23 19.85,116.02
  TOP w0.508: v5(23.14,169.09) 20.1,172.13 20.1,172.77 R21.1 18.96,172.78 v1(18.95,172.77) 18.96,172.76 R444.1 ; C227.1 v2(23.77,120.96)
  TOP w1.016: 50.98,99.01 47.88,99.01 36.85,110.03 v1(33.93,110.03) 30.12,110.03 29.94,110.21 ; 85.67,44.32 85.67,39.14 v1(84.99,38.46) 78.23,31.7 73.97,31.7 71.28,29.01 PR133.1
  IN2 w0.508: 18.79,120.96 v2(23.77,120.96) 29.61,126.8 29.61,165.91 26.44,169.09 v5(23.14,169.09)
  IN2 w1.016: 83.36,45.42 78.81,49.96 78.81,52.07 75.36,55.52 74.5,55.52 65.73,64.29 65.73,69.42 65.56,69.6 65.56,71.53 65.73,71.7 65.73,78.21 66.83,79.3 66.83,80.34
  BOTTOM w1.016: 72.06,86.89 62.79,86.89 53.62,96.06 53.62,97.32
  vias: v2(16.53,114.66) v2(16.51,113.97) v2(26.68,112.42) v2(26.66,111.79) v2(52.44,98.5) v2(53.14,98.5) v2(67.08,82.04) v2(67.79,82.65) v2(72.52,85.44) v2(73.25,85.45) v2(84.33,45.16) v2(84.83,44.7)
+3VLANVCC_S2: length 1
  TOP w0.127: PC116.1 v1(66.7,28.35)
+3VLCD_CON:
  vias: v1(49.17,181.79) v2(61.36,180.42) v2(61.36,179.78) v2(62,179.78)
+3VPCU: length 724.3
  TOP w0.178: U11.114 44,80.63 44.36,80.98 44.36,81.64 ; U11.121 41.2,80.62 41.06,80.76 40.94,80.76 39.77,81.93 C329.1 ; 44.99,62.34 45.2,62.56 U11.50 ; U11.106 47.2,81.38 C332.1
  TOP w0.203: C340.1 71.97,79.3 71.2,80.06 U9.15 ; C345.1 55.26,77.91 53.89,76.53 U11.92 ; C377.1 34.7,67.76 35.58,67.76 35.96,68.13 U11.26
  TOP w0.254: 26.69,40.95 26.44,40.69 26.44,38.66 26.19,38.41 25.93,38.41 ; 26.69,40.95 RP4.10 ; 26.69,40.95 26.29,41.35 25.19,41.35 24.74,41.8 24.74,42.16 24.92,42.34 RP3.5 26.19,42.34 26.44,42.59 26.44,44.62 ; 25.93,38.41 26.22,38.11 26.22,37.77 ; 25.93,38.41 RP4.5
  TOP w0.305: CN14.16 200.14,22.75
  TOP w0.381: CN5.1 30.8,175.48 31.52,176.2 EC5.2 C69.2 v2(29.5,176.83) ; R224.1 49.05,82.33 48.53,81.81 v2(48.2,81.81) 47.63,81.81 C332.1 ; v2(40.47,81.9) 39.78,82.59 C329.1 ; PR4.1 v2(129.06,185.84) ; R190.1 R182.1 49.91,91.61 v2(50.14,91.38) ; R276.2 v2(25.68,98.22) ; v2(54.25,82.35) 54,82.6 R228.1 ; 26.44,44.62 26.69,44.88 RP3.10 27.46,44.88 27.65,45.07 27.65,45.84 27.15,46.33 v2(27,46.33) 27.53,46.86 27.53,48.69 v1(28.6,49.76) 28.6,50.58 31.88,53.86 31.88,56.69 34.27,59.09 34.27,62.5 34.39,62.61 34.39,64.39 34.86,64.86 C379.1 36.13,64.86 v2(36.17,64.82) 36.74,64.25 36.94,64.25 38.84,62.34 41.81,62.34 42.26,62.79 44.02,62.79 44.47,62.34 44.99,62.34 ; v2(43.79,81.08) 44.36,81.64 C333.1 ; v2(35.1,18.97) 35.1,19.08 35.51,19.48 R393.1 R389.1
  TOP w0.508: v2(55.04,75.72) 55.07,75.75 R261.1 ; C340.1 73.04,79.56 72.78,79.83 v2(72.16,79.83) ; R267.1 193.06,72.57 193.71,71.92 194.22,71.92 198.27,67.87 199.12,67.87 199.79,67.19 199.79,59.21 199.39,58.8 v2(199.11,58.8) 197.96,58.8 196.74,57.58 193.98,57.58 D9.2 ; 60.89,58.78 60.89,60.75 v1(60.88,60.76) 60.89,60.76 D8.1 ; 60.89,58.78 60.55,58.45 59.41,58.45 v2(59.05,58.8) ; 60.89,58.78 60.89,58.77 61.64,58.01 61.64,54.94 60.35,53.65 PD11.1 57.24,52.39 57.24,52.01 56.95,51.71 56.11,51.71 56.01,51.82 55.21,51.82 v2(55.08,51.69) ; v2(60.06,75.62) 60.35,75.62 60.72,75.99 EC28.1 ; v2(63.4,78.82) 62.56,78.82 v1(61.77,78.03) 60.72,76.98 EC28.1 ; C345.1 55.26,78.46 54.9,78.82 v2(54.51,78.82) ; R200.1 35.96,87.69 v2(35.84,87.81) ; 26.22,37.77 26.6,37.39 28.54,37.39 28.82,37.68 v2(28.82,37.69) 29.99,36.53 29.99,20.74 31.72,19 35.08,19 v2(35.1,18.97) ; v2(201.73,22.1) 201.07,22.75 200.14,22.75 ; EC28.1 L18.2 ; C377.1 v2(34.69,68.48) ; v2(32.08,78.47) 32.02,78.53 R237.1 ; PR214.2 v2(89.12,175.49) ; R207.2 34.18,86.74 L17.2 34,87.47 v2(34,87.81) ; R57.2 v2(24.53,176.33) ; v2(57.43,70.92) R279.1
  IN1 w0.381: v2(39.34,175.64) 40.3,176.6 47.6,176.6 50.06,179.06 50.06,180.06 51.16,181.15 54.13,181.15 55.43,182.46 64.06,182.46 65.37,181.15 74.83,181.15 v2(76.73,183.06)
  IN1 w0.508: v2(39.34,175.64) 35.51,175.64 34.32,176.83 v2(29.5,176.83) 28.74,176.07 24.79,176.07 v2(24.53,176.33) ; v2(32.08,78.47) 32.23,78.63 34.31,78.63 v2(34.57,78.37) ; v2(40.47,81.9) 36.87,81.9 v2(35.99,82.78) ; v2(60.06,75.62) 59.92,75.75 55.07,75.75 v2(55.04,75.72) ; v2(129.06,185.84) 128.42,186.48 125.42,186.48 119.41,180.47 111.99,180.47 104.47,172.95 100.34,172.95 97.6,175.69 89.33,175.69 v2(89.12,175.49)
  IN2 w0.381: v2(50.14,91.38) 50.14,89.54 43.76,83.16
  IN2 w0.508: v2(124.69,5.77) 124.69,5.72 123.76,4.79 114.97,4.79 113.1,6.66 88.29,6.66 85.98,8.97 73.28,8.97 69.82,12.42 62.84,12.42 62.3,12.95 43.25,12.95 42.44,13.77 40.33,13.77 35.94,18.16 35.46,18.16 35.1,18.52 v2(35.1,18.97) ; v2(201.51,56.38) 203.48,54.41 203.48,24.56 202.97,24.05 202.97,23.16 202.6,22.78 202.51,22.78 201.83,22.1 v2(201.73,22.1) ; v2(59.05,58.8) 58.62,59.23 58.62,59.69 55.65,62.66 55.65,64.32 55.4,64.57 55.4,72.03 54.58,72.85 54.58,75.26 v2(55.04,75.72) ; v2(89.12,175.49) 86.91,177.7 82.09,177.7 v2(76.73,183.06) ; v2(28.82,37.69) 28.91,37.78 28.91,40.51 28.42,41 27.66,41 27.2,41.46 27.2,46.13 v2(27,46.33) ; v2(36.17,64.82) 36.17,65.67 34.69,67.14 v2(34.69,68.48) 34.34,68.48 34.02,68.8 34.02,72.4 34.57,72.95 v2(34.57,78.37) 34.57,81.36 v2(35.99,82.78) 35.99,87.66 v2(35.84,87.81) 35.84,87.75 35.36,87.27 34.54,87.27 v2(34,87.81) 34,88.89 35.74,90.63 35.74,93.62 33.68,95.68 28.22,95.68 v2(25.68,98.22) 26.44,98.22 34.31,106.1 34.31,154.38 33.46,155.23 33.46,161.37 36.98,164.89 36.98,173.28 v2(39.34,175.64)
  BOTTOM w0.508: v2(199.11,58.8) 199.11,58.78 v2(201.51,56.38) ; v2(201.73,22.1) 199.9,22.1 198.6,23.39 191.59,23.39 189.74,21.54 188.97,21.54 188.59,21.92 185.49,21.92 181.51,17.93 181.51,14.15 179.47,12.12 176.75,12.12 176.15,11.51 175.95,11.51 175.51,11.07 169.25,11.07 169.2,11.02 168.67,11.02 168.62,11.07 167.31,11.07 164.56,13.82 162.84,13.82 161.92,14.74 152.04,14.74 152.03,14.76 149.72,14.76 149.7,14.74 147.92,14.74 144.3,11.13 129.9,11.13 129.87,11.16 127.22,11.16 127.19,11.13 125.7,11.13 124.69,10.11 v2(124.69,5.77) ; v2(52.04,81) 54.13,78.82 v2(54.51,78.82) 56.13,77.19 56.13,76.42 56.08,76.37 56.08,76.33 55.47,75.72 v2(55.04,75.72) 55.04,75.36 57.43,72.97 v2(57.43,70.92) ; v2(72.16,79.83) 72.16,79.71 71.06,78.61 63.52,78.61 63.4,78.73 v2(63.4,78.82)
