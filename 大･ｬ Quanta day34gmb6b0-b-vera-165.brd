# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HWPG: length 363.2
  TOP w0.127: v2(42.44,46.53) 44.4,46.53 46.2,48.34 54.08,48.34 55.24,49.49 56.65,49.49 PR111.2 57.64,50.06 PR110.2 58.23,50.29 v2(58.92,49.6) 58.92,50.01 v1(60.09,51.18) 60.93,52.02 60.93,53.34 62.17,54.57 62.17,73.1 63.77,74.7 v2(63.79,74.7) ; U12.4 87.15,72.42 v2(87.11,72.45) ; v2(110.84,91.06) 111.02,91.24 112.16,91.24 112.93,92 D2.1 ; v2(88.58,70.08) 88.87,70.37 U12.1 ; v2(57.4,81.33) 57.22,81.15 57.22,81.15 56.93,80.85 53.46,80.85 C335.2 52.3,81.46 52.18,81.57 51.06,81.57 50.4,80.91 U11.98 ; v2(88.28,67.33) 88.15,67.46 U12.13 ; PR132.1 102.13,34.09 101.75,33.71 101.75,32.66 100.99,31.9 100.99,31.78 98.58,29.36 v2(98.12,29.36) 94.41,29.36 94.26,29.52 84.45,29.52 82.66,27.72 82.66,27.5 82.18,27.03 v2(81.56,27.03) ; PR107.2 190.6,61.14 v2(191.04,60.69) ; v2(85.6,67.74) 85.78,67.57 86.53,67.57 86.65,67.68 U12.10
  IN1 w0.14: v2(63.79,74.7) 63.78,74.7 65.91,72.57 76.65,72.57 77.48,73.39 86.17,73.39 v2(87.11,72.45)
  IN2 w0.14: v2(98.12,29.36) 98.12,29.06 99.59,27.58 99.59,20.7 105.26,15.04 109.42,15.04 111.46,17.08 117.64,17.08 118.37,16.35 120.16,16.35 120.89,17.08 150.44,17.08 150.87,16.64 158.72,16.64 159.6,15.75 161.88,15.75 162.89,14.74 165.79,14.74 167.31,16.26 170.05,16.26 174.2,20.4 174.44,20.4 180.15,26.11 180.15,26.4 182.09,28.34 182.09,31.94 183.38,33.22 184.52,33.22 186.32,35.02 186.32,41.89 187.23,42.8 187.23,46.5 184.29,49.44 184.29,51.73 186.18,53.62 186.64,53.62 187.34,54.32 187.87,54.32 188.87,55.32 188.87,58.52 v2(191.04,60.69) ; v2(87.11,72.45) 86.34,71.68 85.37,71.68 84.41,70.72 84.41,68.93 v2(85.6,67.74) 85.66,67.8 87.8,67.8 v2(88.28,67.33) 88.58,67.62 v2(88.58,70.08) ; v2(81.56,27.03) 80.77,27.81 80.77,28.92 68.22,41.47 68.22,41.78 66.07,43.94 63,43.94 60.17,46.77 60.17,48.47 59.04,49.6 v2(58.92,49.6)
  BOTTOM w0.127: v2(63.79,74.7) 63.79,74.71 63.28,75.22 63.28,75.45 v2(57.4,81.33) ; PR166.1 197.89,69.01 199.13,67.77 199.13,63.47 197.28,61.62 191.39,61.62 191.04,61.28 v2(191.04,60.69) ; v2(42.44,46.53) 42.44,46.38 42.21,46.14 PR181.2 ; v2(87.11,72.45) 87.11,72.49 87.77,73.15 88.45,73.15 88.77,72.82 92.35,72.82 93.09,73.56 93.09,74.07 96.04,77.01 99.84,77.01 102.32,79.5 102.32,82.79 104.1,84.57 108.16,84.57 110.84,87.25 v2(110.84,91.06)
I2C0_SCL: length 15.3
  BOTTOM w0.076: 168.19,101.8 168.14,101.75 166.87,101.75 U25.F3
  BOTTOM w0.127: 168.19,101.8 168.45,101.8 172.49,105.84 173.71,105.84 v1(173.99,105.56) 174.54,105.02 176.68,105.02 177.21,104.49 177.44,104.25 178.6,104.25 178.84,104.01 RP6.1
I2C0_SDA: length 16.3
  BOTTOM w0.076: 167.29,102.04 167.68,102.42 168.29,102.42
  BOTTOM w0.089: U25.F2 167.29,102.04
  BOTTOM w0.127: 168.29,102.42 172.21,106.35 176.15,106.35 v1(176.53,105.97) 177.19,105.97 177.57,105.59 177.57,105.08 177.89,104.76 179.2,104.76 180.11,103.85 RP6.3
I2C1_SCL: length 14.6
  BOTTOM w0.127: RP6.2 179.47,104.06 179.03,104.51 177.63,104.51 176.71,105.44 175.64,105.44 v1(175.26,105.82) 174.98,106.1 172.36,106.1 168.34,102.08 U25.F1
I2C1_SDA: length 18.6
  TOP w0.127: RP2.8 181.81,105.81 179.91,103.91 174.24,103.91 v1(173.76,103.43) 173.35,103.02 169.8,103.02 167.92,101.14 167.14,101.14 v3(166.91,100.92)
  BOTTOM w0.127: v3(166.91,100.92) 166.37,100.92 U25.G4
IDEA_G: length 5.9
  BOTTOM w0.254: PQ38.3 71.53,177.24 72.55,177.24 PR210.2 72.64,177.42 73.46,178.24 v1(74.17,178.24) 75.08,179.15 75.08,179.68 74.89,179.87 PQ33.4
IMVP_PWRGD: length 101
  TOP w0.127: R221.2 56.06,83.74 v2(56.46,83.34) ; v2(114.91,95.63) 114.91,94.63 113.87,93.59 113.87,91.41 112.29,89.84 v1(112.04,89.84) 111.54,89.35 111.54,87.87 108.7,85.03 102.87,85.03 102,85.9 100.98,85.9 PR77.1 PR76.2 99.65,86.84 99.65,87.06 v2(99.64,87.07)
  IN1 w0.14: v2(56.46,83.34) 56.48,83.32 63.07,83.32 64.9,85.15 71.32,85.15 72.19,86.02 80.38,86.02 84.1,82.3 86.56,82.3 87.31,83.05 88.03,83.05 91.39,86.41 91.39,86.79 92.28,87.68 99.03,87.68 v2(99.64,87.07)
  BOTTOM w0.076: U25.C59 132.01,104.45 131.63,104.83 131.63,105.08 131.52,105.2 131.52,105.69 130.86,106.35 130.74,106.35
  BOTTOM w0.127: v2(114.91,95.63) 114.91,96.46 116.25,97.81 116.25,100.2 118.82,102.76 118.82,105.64 119.43,106.25 121.04,106.25 R494.1 122.36,105.74 127.87,105.74 128.58,106.45 130.64,106.45 130.74,106.35
IN_CLK: length 154.5
  TOP w0.127: v2(25.78,85.43) 25.51,85.7 24.87,85.7 24.57,85.4 24.57,84.42 24.15,84 23.14,84 C327.1
  IN1 w0.14: v2(104.86,107.84) 104.63,107.61 104.63,107.36 104.35,107.07 103.25,107.07 102.72,106.55 100.32,106.55 82.27,88.5 70.46,88.5 69.34,87.38 63.85,87.38 62.49,86.02 39.28,86.02 38.3,87 31.6,87 31.27,86.67 29.72,86.67 28.6,87.78 28.6,89.46 27.97,90.09 27.41,90.09 27.15,89.84 27.15,88.44 26.76,88.05 26.21,88.05 25.82,88.44 25.82,90.17 25.56,90.42 25.2,90.42 24.94,90.17 24.94,87.4 25.2,87.13 28.07,87.13 28.43,86.78 28.43,86.07 28.02,85.66 26,85.66 v2(25.78,85.43)
  BOTTOM w0.127: U25.B57 132.82,105.18 132.82,107.13 129.39,110.57 129,110.57 123.64,115.93 121.57,115.93 120.86,116.64 120.43,116.64 v1(119.94,116.14) 119.44,116.64 119.18,116.64 118.67,116.13 106.96,116.13 103.03,112.2 103.03,109.11 103.48,108.66 104.24,108.66 104.57,108.33 104.57,108.14 v2(104.86,107.84)
IN_CLK#: length 154.5
  TOP w0.127: C324.1 22.76,84.4 22.93,84.23 24.06,84.23 24.34,84.51 24.34,85.5 24.78,85.93 25.51,85.93 v2(25.78,86.2)
  IN1 w0.14: v2(25.78,86.2) 26.05,85.92 27.91,85.92 28.17,86.18 28.17,86.67 27.96,86.87 25.09,86.87 24.67,87.29 24.67,90.28 25.08,90.69 25.67,90.69 26.08,90.28 26.08,88.55 26.32,88.32 26.65,88.32 26.88,88.55 26.88,89.95 27.29,90.36 28.08,90.36 28.87,89.57 28.87,87.89 29.83,86.93 31.16,86.93 31.49,87.27 38.41,87.27 39.39,86.28 62.38,86.28 63.74,87.64 69.23,87.64 70.35,88.77 82.16,88.77 100.21,106.81 102.61,106.81 103.14,107.34 104.24,107.34 104.37,107.47 104.37,107.58 v2(104.1,107.84)
  BOTTOM w0.127: U25.A57 133.05,105.6 133.05,107.23 129.48,110.8 129.09,110.8 123.73,116.15 121.66,116.15 120.95,116.87 120.48,116.87 v1(119.94,117.41) 119.39,116.87 119.08,116.87 118.57,116.36 106.86,116.36 102.8,112.29 102.8,109.02 103.38,108.43 104.15,108.43 104.34,108.24 104.34,108.08 v2(104.1,107.84)
IN_D0: length 146.7
  TOP w0.127: v2(29.93,85.13) 29.66,85.4 28.93,85.4 28.27,84.73 27.38,84.73 24.48,81.84 23.33,81.84 22.63,81.14 22.23,81.14 20.55,79.45 20.09,79.45 19.84,79.21 C343.1
  IN1 w0.14: v2(29.93,85.13) 30.14,85.34 31.21,85.34 32.08,86.21 37.94,86.21 38.92,85.23 62.95,85.23 64.31,86.59 70.28,86.59 71.4,87.71 82.79,87.71 84.38,89.3 84.38,89.37 100.57,105.56 104.08,105.56 104.44,105.91 104.44,106.25 v2(104.68,106.5)
  BOTTOM w0.127: v2(104.68,106.5) 104.42,106.76 104.42,106.96 104.06,107.32 103.34,107.32 102.29,108.37 102.29,112.53 106.65,116.89 114.7,116.89 115.62,117.81 118.02,117.81 v1(118.54,117.28) 119.06,117.81 119.45,117.81 119.6,117.96 120.68,117.96 121.98,116.66 123.95,116.66 129.28,111.33 129.67,111.33 133.98,107.02 133.98,106.51 134.36,106.13 134.36,105.87 134.14,105.64 134.14,105.38 134.26,105.26 134.42,105.26 134.52,105.36 U25.A55
IN_D0#: length 146.7
  TOP w0.127: v2(29.93,85.89) 29.66,85.62 28.83,85.62 28.17,84.96 27.28,84.96 24.39,82.07 23.24,82.07 22.53,81.37 22.14,81.37 20.45,79.68 20.23,79.68 C339.1
  IN1 w0.14: v2(29.93,85.89) 30.2,85.61 31.1,85.61 31.97,86.48 38.05,86.48 39.03,85.5 62.84,85.5 64.2,86.86 70.17,86.86 71.13,87.82 71.29,87.98 82.68,87.98 84.12,89.41 84.12,89.48 100.46,105.82 103.97,105.82 104.17,106.02 104.17,106.25 v2(103.92,106.5)
  BOTTOM w0.127: U25.B55 134.85,105.19 134.85,105.64 134.59,105.89 134.59,106.22 134.21,106.6 134.21,107.11 129.76,111.56 129.37,111.56 124.04,116.89 122.07,116.89 120.77,118.19 119.51,118.19 119.35,118.03 119.06,118.03 v1(118.54,118.55) 118.02,118.03 115.52,118.03 114.61,117.12 106.56,117.12 102.06,112.63 102.06,108.27 103.25,107.09 103.97,107.09 104.19,106.86 104.19,106.76 v2(103.92,106.5)
IN_D1: length 151.5
  TOP w0.127: v2(29.84,88.44) 29.57,88.71 29.27,88.71 27.74,90.23 27.47,90.23 27.27,90.04 27.27,89.76 29.38,87.65 29.38,86.94 28.07,85.62 27.14,85.62 24.12,82.6 21.99,82.6 20.85,81.46 20.23,81.46 C336.1
  IN1 w0.14: v2(104.86,109.19) 104.61,108.94 104.61,108.67 104.33,108.39 102.92,108.39 102.62,108.69 102.62,109.86 102.46,110.02 102.18,110.02 101.97,109.81 101.97,107.68 101.63,107.33 99.81,107.33 81.76,89.29 69.95,89.29 68.88,88.21 63.42,88.21 62.65,87.44 53.76,87.44 53.24,86.92 51.29,86.92 50.39,87.82 49.67,87.82 49.53,87.68 49.53,87.1 49.23,86.8 48.52,86.8 48.22,87.1 48.22,87.68 48.08,87.82 47.55,87.82 47.41,87.68 47.41,87.11 47.11,86.82 46.4,86.82 46.1,87.11 46.1,87.68 45.96,87.82 45.12,87.82 44.6,87.3 43.47,87.3 42.95,87.82 36.46,87.82 35.64,88.64 32.99,88.64 32.41,88.06 31.72,88.06 31.14,88.64 30.03,88.64 v2(29.84,88.44)
  BOTTOM w0.076: 131.98,106.86 131.99,106.85 131.99,106.59 132.4,106.18 132.4,104.8 132.28,104.69 132.28,104.39 132.58,104.1 U25.C58
  BOTTOM w0.127: 131.98,106.86 131.98,106.94 129.11,109.8 128.72,109.8 123.39,115.14 112.01,115.14 111.42,114.55 110.88,114.55 v1(110.39,114.06) 109.87,114.58 109.14,114.58 108.48,115.24 107.15,115.24 104.93,113.01 104.93,111.3 104.62,111 104.62,109.44 v2(104.86,109.19)
IN_D1#: length 151.5
  TOP w0.127: C331.1 19.84,81.83 19.99,81.69 20.76,81.69 21.9,82.83 24.03,82.83 27.05,85.85 27.97,85.85 29.15,87.03 29.15,87.56 27.04,89.67 27.04,90.13 27.37,90.46 27.84,90.46 29.36,88.94 29.57,88.94 v2(29.84,89.21)
  IN1 w0.14: v2(104.1,109.19) 104.34,108.95 104.34,108.78 104.22,108.66 103.03,108.66 102.89,108.8 102.89,109.97 102.57,110.29 102.07,110.29 101.71,109.92 101.71,107.79 101.52,107.6 99.7,107.6 81.65,89.55 69.84,89.55 68.77,88.48 63.31,88.48 62.54,87.71 53.65,87.71 53.13,87.19 51.4,87.19 50.5,88.09 49.56,88.09 49.26,87.79 49.26,87.21 49.12,87.07 48.63,87.07 48.49,87.21 48.49,87.79 48.19,88.09 47.44,88.09 47.14,87.79 47.14,87.22 47,87.08 46.51,87.08 46.37,87.22 46.37,87.79 46.07,88.09 45.01,88.09 44.49,87.57 43.58,87.57 43.06,88.09 36.57,88.09 35.75,88.91 32.88,88.91 32.3,88.33 31.83,88.33 31.25,88.91 30.13,88.91 v2(29.84,89.21)
  BOTTOM w0.076: 132.21,106.86 132.21,106.84 132.16,106.8 132.16,106.66 132.58,106.25 U25.B58
  BOTTOM w0.127: 132.21,106.86 132.21,107.03 129.2,110.03 128.81,110.03 123.48,115.37 111.91,115.37 111.33,114.78 110.93,114.78 v1(110.39,115.33) 109.87,114.81 109.24,114.81 108.58,115.47 107.06,115.47 104.7,113.11 104.7,111.4 104.39,111.09 104.39,109.49 v2(104.1,109.19)
IN_D2: length 152.7
  TOP w0.127: C354.1 19.84,77.1 20.04,77.29 20.34,77.29 20.65,77.6 20.65,78.19 22.42,79.96 25.9,79.96 26.24,80.3 26.24,82.55 26.77,83.08 27.04,83.08 v2(27.28,82.84)
  IN1 w0.14: v2(103.92,105) 103.67,104.75 103.67,104.49 103.39,104.2 100.33,104.2 85.17,89.04 85.17,88.98 83.12,86.93 71.73,86.93 70.6,85.8 64.64,85.8 62.82,83.99 55.9,83.99 55.53,83.61 35.19,83.61 34.8,83.22 32.55,83.22 31.76,84.02 29,84.02 28.05,83.06 27.5,83.06 v2(27.28,82.84)
  BOTTOM w0.076: 135.1,105.16 135.1,105.14 135.13,105.11 135.13,105 134.52,104.4 U25.C55
  BOTTOM w0.127: v2(103.92,105) 103.66,105.26 103.66,105.48 101.56,107.58 101.56,112.86 106.48,117.78 114.39,117.78 116.07,119.46 119.56,119.46 120.2,118.82 120.86,118.82 121.54,118.14 121.93,118.14 v1(122.45,117.61) 122.97,118.14 123.51,118.14 129.56,112.09 129.95,112.09 135.1,106.94 135.1,105.16
IN_D2#: length 152.7
  TOP w0.127: v2(27.28,83.6) 26.99,83.31 26.68,83.31 26.01,82.64 26.01,80.39 25.8,80.19 22.32,80.19 20.42,78.28 20.42,77.69 20.25,77.52 20.1,77.52 C349.1
  IN1 w0.14: v2(27.28,83.6) 27.55,83.33 27.94,83.33 28.89,84.28 31.87,84.28 32.66,83.49 34.69,83.49 35.08,83.88 55.41,83.88 55.79,84.25 62.71,84.25 64.52,86.07 70.49,86.07 71.62,87.19 83.01,87.19 84.9,89.09 84.9,89.15 100.22,104.47 103.28,104.47 103.41,104.6 103.41,104.75 v2(103.16,105)
  BOTTOM w0.076: 135.33,105.16 135.33,105.14 135.3,105.11 135.3,104.77 135.38,104.7 135.38,104.37 135.08,104.07 U25.C54
  BOTTOM w0.127: 135.33,105.16 135.33,107.03 130.04,112.32 129.65,112.32 123.61,118.36 122.97,118.36 v1(122.45,118.88) 121.93,118.36 121.64,118.36 120.95,119.05 120.29,119.05 119.66,119.69 115.97,119.69 114.3,118.01 106.38,118.01 101.33,112.96 101.33,107.49 103.43,105.39 103.43,105.27 v2(103.16,105)
INT_BT_OFF#: length 5.9
  TOP w0.127: CN22.51 v1(197.4,161.6) 196.82,161.01 R74.1 R90.2 Q3.3
INT_EDP_AUXN: length 127.9
  TOP w0.127: C33.2 v2(57.3,175.65)
  IN1 w0.14: v2(119.01,127.19) 119.19,127.19 119.51,127.51 119.51,127.71 119.06,128.15 117.92,128.15 116.12,129.96 102.02,129.96 99.54,132.44 99.54,138.79 79.22,159.11 67.57,159.11 58.61,168.06 58.61,175.99 58.3,176.3 56.68,176.3 56.48,176.1 56.48,175.62 56.64,175.46 56.87,175.46 57.05,175.65 v2(57.3,175.65)
  BOTTOM w0.127: v2(119.01,127.19) 119.2,127.19 119.6,126.79 119.6,125.91 122.87,122.64 124.4,122.64 131.04,116 131.54,116 135.95,111.6 136.52,111.6 136.94,111.18 137.8,111.18 138.17,110.8 v1(138.17,110.03) 139,110.03 140.77,108.26 140.77,105.62 U25.A45
INT_EDP_AUXN_R: length 6.1
  TOP w0.127: CN2.31 57.85,177.33 57.71,177.19 57.71,176.36 57.43,176.07 57.12,176.07 56.79,175.75 56.79,174.74 C33.1 56.78,173.71 56.78,173.48 R40.2
INT_EDP_AUXP: length 127.9
  TOP w0.127: C32.2 v2(56.03,175.65)
  IN1 w0.14: v2(119.83,127.19) 119.78,127.24 119.78,127.82 119.17,128.42 118.03,128.42 116.23,130.23 102.13,130.23 99.81,132.55 99.81,138.9 79.33,159.37 67.68,159.37 58.88,168.17 58.88,176.1 58.41,176.57 56.57,176.57 56.21,176.21 56.21,175.82 v2(56.03,175.65)
  BOTTOM w0.127: U25.B45 140.99,105.2 140.99,108.36 139.08,110.27 v1(139.08,110.92) 138.38,110.92 137.89,111.4 137.04,111.4 136.61,111.83 136.04,111.83 131.64,116.23 131.13,116.23 124.49,122.87 122.96,122.87 119.83,126.01 v2(119.83,127.19)
INT_EDP_AUXP_R: length 6.1
  TOP w0.127: R39.2 56.55,173.48 56.55,173.71 C32.1 56.56,174.76 56.56,175.84 57.02,176.3 57.33,176.3 57.49,176.45 57.49,177.13 57.35,177.27 CN2.32
INT_EDP_TXN0: length 128.4
  TOP w0.127: C35.2 53.12,172.51 52.34,172.51 52.07,172.24 52.07,170.33 v1(51.56,169.82) 51.69,169.82 52.07,169.44 52.07,169.33 v2(51.84,169.1)
  IN1 w0.14: v2(119.09,126.56) 118.81,126.28 118.81,125.84 118.36,125.39 117.24,125.39 114.44,128.18 100.88,128.18 97.36,131.7 97.36,137.87 77.87,157.35 62.77,157.35 52.02,168.1 52.02,168.93 v2(51.84,169.1)
  BOTTOM w0.076: 140.41,106.3 140.41,106.28 140.37,106.24 140.37,104.69 140.66,104.4 U25.C45
  BOTTOM w0.127: v2(119.09,126.56) 118.82,126.29 118.82,125.97 122.66,122.13 124.19,122.13 130.83,115.49 131.3,115.49 135.7,111.09 136.31,111.09 140.41,106.99 140.41,106.3
INT_EDP_TXN0_R: length 8.2
  TOP w0.127: C35.1 54.08,172.17 54.18,172.08 54.54,172.08 54.68,172.22 54.68,173.08 v1(53.85,173.91) 54.68,174.75 54.68,175.51 55.24,176.07 55.47,176.07 55.99,176.59 55.99,177.14 55.85,177.28 CN2.35
INT_EDP_TXN1: length 131.9
  TOP w0.127: v2(50.7,170.99) 50.95,171.25 50.95,172.07 50.21,172.8 50.21,174.27 50.95,175.01 51.48,175.01 C8780.2
  IN1 w0.14: v2(117.59,127.36) 117.26,127.69 117.26,127.93 115.85,129.34 101.5,129.34 98.72,132.12 98.72,138.44 78.7,158.46 65.26,158.46 51.86,171.86 51.23,171.86 50.91,171.54 50.91,171.21 v2(50.7,170.99)
  BOTTOM w0.076: 139.55,106.35 139.55,106.33 139.58,106.3 139.58,105.56 U25.A47
  BOTTOM w0.127: 139.55,106.35 139.55,106.49 135.91,110.13 135.3,110.13 130.93,114.5 130.45,114.5 123.79,121.17 122.18,121.17 117.92,125.43 117.28,125.43 115.85,126.85 115.85,127.88 116.29,128.32 116.86,128.32 117.24,127.94 117.24,127.7 v2(117.59,127.36)
INT_EDP_TXN1_R: length 5.6
  TOP w0.127: CN2.38 54.35,177.22 54.48,177.09 54.48,176.73 53.95,176.2 v1(53.18,176.2) 53.31,176.07 53.31,174.82 53.07,174.57 52.97,174.57 52.7,174.57 52.48,174.79 C8780.1
INT_EDP_TXP0: length 128.4
  TOP w0.127: v2(52.68,169.1) 52.41,169.1 52.3,169.22 52.3,169.52 52.6,169.82 v1(52.83,169.82) 52.3,170.36 52.3,172.14 52.43,172.28 53.42,172.28 53.57,172.14 53.57,171.69 C36.2
  IN1 w0.14: v2(52.68,169.1) 52.36,169.1 52.28,169.02 52.28,168.21 62.88,157.62 77.99,157.62 97.62,137.98 97.62,131.81 100.99,128.45 114.55,128.45 117.35,125.65 118.25,125.65 118.55,125.95 118.55,126.28 v2(118.27,126.56)
  BOTTOM w0.076: 140.18,106.35 140.18,106.28 140.21,106.26 140.21,104.65 U25.B46
  BOTTOM w0.127: v2(118.27,126.56) 118.59,126.24 118.59,125.88 122.56,121.91 124.09,121.91 130.73,115.27 131.21,115.27 135.61,110.86 136.21,110.86 140.18,106.9 140.18,106.35
INT_EDP_TXP0_R: length 8.2
  TOP w0.127: C36.1 54.08,171.56 54.38,171.85 54.64,171.85 54.91,172.13 54.91,173.18 54.61,173.48 54.61,173.71 54.81,173.91 v1(55.12,173.91) 54.91,174.12 54.91,175.42 55.34,175.84 55.57,175.84 56.21,176.49 56.21,177.15 56.35,177.28 CN2.34
INT_EDP_TXP1: length 131.8
  TOP w0.127: v2(51.46,170.99) 51.26,170.99 51.18,171.07 51.18,172.16 50.44,172.9 50.44,174.17 51.05,174.78 51.81,174.78 51.92,174.68 51.92,174.18 C8779.2
  IN1 w0.14: v2(51.46,170.99) 51.28,170.99 51.18,171.09 51.18,171.43 51.34,171.59 51.75,171.59 65.15,158.19 78.59,158.19 98.45,138.33 98.45,132.01 101.39,129.07 115.74,129.07 116.99,127.82 116.99,127.57 v2(116.77,127.36)
  BOTTOM w0.076: U25.B47 139.83,105.16 139.83,105.74 139.74,105.82 139.74,106.3 139.77,106.33 139.77,106.35
  BOTTOM w0.127: v2(116.77,127.36) 117.02,127.6 117.02,127.85 116.77,128.09 116.38,128.09 116.08,127.79 116.08,126.95 117.37,125.65 118.02,125.65 122.28,121.4 123.88,121.4 130.55,114.73 131.02,114.73 135.4,110.35 136,110.35 139.77,106.58 139.77,106.35
INT_EDP_TXP1_R: length 5.6
  TOP w0.127: 54.07,175.31 v1(54.07,175.3) ; 54.07,175.31 54.07,176 54.71,176.64 54.71,177.11 54.85,177.25 CN2.37 ; 54.07,175.31 53.85,175.54 53.62,175.54 53.54,175.46 53.54,174.73 53.16,174.35 52.86,174.35 C8779.1
INT_RF_OFF#: length 10.7
  TOP w0.127: R95.1 185.37,158.79 v2(185.09,158.51) ; v2(190.55,159.3) v1(190.55,158.54) Q3.6
  IN2 w0.14: v2(190.55,159.3) 189.12,159.3 187.81,157.99 185.61,157.99 v2(185.09,158.51)
  BOTTOM w0.127: v2(185.09,158.51) 185,158.42 CN22.20
ISOLATEB: length 7.9
  TOP w0.127: v1(16.03,120.19) 16.6,120.77 R143.1 R144.2 18.42,120.76 R145.2 18.42,119.43 19.07,118.78 19.07,118.24 19.38,117.93 19.38,117.48 19.71,117.15 20.02,117.15 20.09,117.22 U8.20
IT8502_AGND: length 5.8
  TOP w0.127: U11.75 53.52,69.73 55.4,71.62 55.94,71.62 L19.2 57.28,72.09 v1(57.3,72.06)
JTAG_TCK_PCH: length 73.1
  TOP w0.127: v2(86.89,65.52) 87.28,65.91 R286.1 87.24,66.09 86.54,66.79 83.51,66.79 81.87,68.43 80.58,68.43 80.06,67.91 CN8.58
  IN2 w0.14: v2(126.09,92.16) 125.81,92.16 125.51,92.46 119.45,92.46 112.06,85.07 112.06,80.9 103.19,72.02 95.95,72.02 89.89,65.96 87.34,65.96 v2(86.89,65.52)
  BOTTOM w0.127: R564.2 121.82,89.58 121.82,89.59 122.58,90.35 122.58,90.86 v1(122.96,91.24) 122.99,91.26 125.19,91.26 v2(126.09,92.16) 126.88,91.36 128.93,91.36 129.06,91.24 129.51,91.24 129.87,91.59 U25.AE62
JTAG_TDI_PCH: length 79.9
  TOP w0.127: v2(85.71,69.82) 85.42,69.82 84.81,70.43 84.81,72.21 85.64,73.04 86.29,73.04 86.45,73.2 R271.1 ; R271.1 87.1,72.92 86.89,72.92 86.65,72.67 U12.5 ; R271.1 86.25,74.34 84.86,74.34 83.46,75.74 v1(82.68,75.74) 81.41,74.47 80.67,74.47 80.06,73.86 CN8.3
  IN2 w0.14: v2(128.02,92.31) 127.51,92.83 125.88,92.83 125.72,92.99 119.23,92.99 111.53,85.29 111.53,81.28 102.82,72.57 95.69,72.57 94.49,71.37 87.85,71.37 86.3,69.82 v2(85.71,69.82)
  BOTTOM w0.076: v2(128.02,92.31) 128.02,92.16 128.22,91.95 129,91.95 129.1,92.05 129.42,92.05 129.6,92.23 129.6,92.49 129.77,92.66 130.31,92.66 U25.AD61
  BOTTOM w0.127: R548.2 125.38,93.14 126.46,93.14 126.77,92.83 126.98,92.83 127.24,92.58 127.59,92.58 127.86,92.31 v2(128.02,92.31)
JTAG_TDO_PCH: length 104.8
  TOP w0.127: R201.2 115.03,87.3 v1(118.89,91.16) 120.52,92.79 129.53,92.79 130.29,92.04 v2(130.29,91.96) ; U12.2 88.15,71.8 88.56,72.21 88.56,72.82 R271.2 86.77,74.6 84.99,74.6 83.08,76.51 82.46,76.51 R264.2 80.79,74.97 80.16,74.35 79.53,74.35 79.06,73.88 CN8.5 79.06,71.6 83.62,67.04 86.65,67.04 87.03,66.65 87.48,66.65 87.71,66.42 87.71,65.38 R287.2 87.28,64.31 v2(87.34,64.26)
  IN2 w0.14: v2(87.34,64.26) 88.51,65.43 90.19,65.43 96.15,71.39 103.49,71.39 112.6,80.49 112.6,84.85 119.67,91.92 125.27,91.92 125.7,91.49 126.26,91.49 126.29,91.47 129.79,91.47 v2(130.29,91.96)
  BOTTOM w0.127: U25.AE61 130.59,91.67 v2(130.29,91.96)
JTAG_TMS_PCH: length 74
  TOP w0.127: CN8.2 80.56,71.6 84.42,67.74 v2(84.96,67.74) 85.41,68.19 86.14,68.19 U12.9
  IN2 w0.14: v2(127.38,92.16) 126.96,92.59 125.76,92.59 125.63,92.72 119.34,92.72 111.8,85.18 111.8,81.09 103.01,72.3 95.82,72.3 89.91,66.4 86.31,66.4 v2(84.96,67.74)
  BOTTOM w0.076: U25.AD62 129.94,92.31 129.5,91.88 129.16,91.88 129.07,91.79 127.75,91.79 v2(127.38,92.16)
  BOTTOM w0.127: R547.2 122.59,92.89 v1(122.96,92.89) 126.29,92.89 126.57,92.6 126.89,92.6 127.33,92.16 v2(127.38,92.16)
JTAGX_PCH: length 93.8
  TOP w0.127: R287.1 86.38,64.95 85.88,65.46 v2(85.88,65.77) 86.18,65.77 R286.2 86.06,66.53 83.41,66.53 81.73,68.21 80.85,68.21 80.56,67.91 CN8.59
  IN2 w0.076: 131.93,102.84 131.33,102.84 v2(130.91,103.26)
  IN2 w0.14: v2(85.88,65.77) 86.58,65.07 87.08,65.07 87.71,65.7 90.05,65.7 96.02,71.66 103.38,71.66 112.33,80.61 112.33,84.96 119.56,92.19 125.44,92.19 125.89,91.73 126.38,91.73 126.74,92.1 v2(126.74,92.16) 127.17,91.73 129.17,91.73 130.2,92.76 131.88,92.76 132.68,93.57 132.68,95.83 132.64,95.87 132.64,98.21 132.78,98.35 132.78,102.58 132.53,102.84 131.93,102.84
  BOTTOM w0.089: 127.53,91.62 129.26,91.62 U25.AE63
  BOTTOM w0.127: U25.E60 131.24,102.93 v2(130.91,103.26) ; R562.2 R554.2 122.08,92.25 v1(124.23,92.25) 125.12,92.25 125.47,92.61 126.24,92.61 126.68,92.16 v2(126.74,92.16) 127.28,91.62 127.53,91.62
KB_LED_EN: length 205.3
  TOP w0.127: v2(158.7,120.86) 158.7,121.61 157.76,122.55 157.76,124.77 158.14,125.15 158.14,126.54 157.76,126.92 157.76,128.7 160.35,131.29 167.36,131.29 167.79,130.86 168.68,130.86 ; U11.31 37.59,66.13 37.87,65.85 v2(37.87,64.82) ; v2(100.99,104.95) 100.61,104.95 v1(87.65,92) 84.5,88.85 84.5,80.67 86.89,78.28 88.16,78.28 88.66,77.79 88.66,77.69 88.96,77.38 89.06,77.38 92.54,73.9 92.54,73.54 92.86,73.23 92.86,62.54 94.13,61.27 v2(94.13,60.86)
  IN1 w0.14: v2(94.13,60.86) 93.72,60.86 91.41,58.55 73.3,58.55 v2(71.32,60.53)
  IN2 w0.14: v2(100.99,104.95) 102.89,106.86 102.89,108.13 103.4,108.64 105.73,108.64 106.62,109.53 108.99,109.53 110.64,111.18 110.64,113.08 111.28,113.72 117.3,113.72 120.62,117.04 139.14,117.04 140.82,118.72 157.3,118.72 158.7,120.12 v2(158.7,120.86)
  BOTTOM w0.127: v2(37.87,64.82) 38.25,64.44 51.15,64.44 53.31,62.28 61.77,62.28 63.3,60.76 71.09,60.76 v2(71.32,60.53)
L_SPK+: length 306.2
  IN1 w0.635: 185.82,16.69 185.24,16.1 185.24,13.44 183.56,11.76 178.96,11.76 178.58,11.38 177.94,11.38 176.83,10.27 175.73,9.17 172.73,9.17 172.38,8.81 168.24,8.81 166.13,10.92 161.97,10.92 161.55,11.34 161.55,11.57 160.76,12.37 156.77,12.37 156.39,11.99 154.2,11.99 153.21,11 149.63,11 149.29,11.34 141.83,11.34 140.34,9.84 124.95,9.84 123.16,8.05 92.73,8.05 91.46,9.32
  IN2 w0.635: v5(83.36,168.71) 82.22,167.56 82.22,152.43 95.86,138.79 95.86,113.26 78.43,95.84 66.09,95.84 58.19,87.94 58.19,63.51 64.27,57.43 64.27,57.43 69.8,51.91 69.8,50.77 78.36,42.21 78.36,41.32 78.36,40.53 82.6,36.28 83.11,36.28 85.53,33.87 85.53,33.85 87.42,31.95 88.18,31.95 88.74,31.95 90,30.69 90,29.94 93.62,26.32 93.62,17.91 94.03,17.5 94.03,14.17 91.59,11.74
  vias: v2(90.83,9.96) v2(91.46,9.96) v2(185.65,18.47) v2(185.65,17.83)
L_SPK+_R: length 20.8
  TOP w0.635: L6.1 86.64,168.71 87.26,168.08 C27.2 v1(92.56,168.08) 94.07,169.6 104.29,169.6 104.99,170.3 CN3.4
L_SPK-: length 303.6
  IN1 w0.635: 184.38,16.94 183.56,16.13 183.56,13.02 183.19,12.65 178.59,12.65 178.21,12.27 177.57,12.27 175.94,10.64 173,10.64 172.77,10.41 167.89,10.41 165.94,12.37 162.01,12.37 161.49,12.89 161.12,13.26 156.3,13.26 155.97,12.93 149.43,12.93 148.72,12.22 141.46,12.22 139.97,10.73 124.33,10.73 122.67,9.07 94.51,9.07 93.88,9.7
  IN2 w0.635: v5(83.36,170.1) 84.25,169.22 84.25,168.3 83.11,167.16 83.11,153.09 96.95,139.24 96.95,113.08 78.69,94.82 66.51,94.82 59.21,87.51 59.21,63.75 64.64,58.32 64.64,58.32 71.91,51.06 71.91,49.95 79.25,42.61 79.25,40.89 82.97,37.17 83.48,37.17 87.81,32.84 89.24,32.84 90.96,31.13 90.96,30.36 94.51,26.81 94.51,25.82 94.51,18.28 94.99,17.79 94.99,13.01 92.86,10.87
  vias: v2(92.48,9.96) v2(93.11,9.96) v2(185.01,18.47) v2(185.01,17.83)
L_SPK-_R: length 21.1
  TOP w0.635: CN3.3 104.97,171.55 103.91,170.49 93.7,170.49 92.33,169.11 v1(90.8,169.11) 90.77,169.08 C31.2 87.79,169.08 86.76,170.1 L5.1
LAD0: length 362.6
  TOP w0.102: v2(39.04,73.08) 39.04,73.18 38.63,73.58 38.63,73.81 37.91,74.53 U11.10 ; v2(87.37,24.46) 87.01,24.82 R368.1
  IN1 w0.102: v2(87.37,24.46) 87.72,24.82 99.21,24.82 99.77,24.26 105.99,24.26 v2(106.32,23.93)
  IN2 w0.102: v2(177.25,48.26) 177.13,48.39 177.13,56.11 178.08,57.06 178.08,58.13 176.44,59.77 176.44,63.51 176.96,64.03 176.96,64.98 178.51,66.53 178.51,71.68 179.23,72.4 179.23,75.02 179.23,76.3 181.72,78.79 181.72,83.57 183.23,85.08 183.23,88.01 189.94,94.72 189.94,97.45 188.24,99.15 188.24,99.88 187.78,100.34 187.78,101.38 187.25,101.91 187.25,104.52 187.04,104.72 187.04,110.25 188.05,111.26 188.05,111.77 186.74,113.08 186.74,145.02 180.87,150.88 180.87,153.61 v2(180.69,153.8) ; v2(87.37,24.46) 86.94,24.89 86.94,27.11 83.89,30.16 82.79,30.16 70.53,42.42 70.53,42.92 66.11,47.33 66.11,48.11 65.33,48.9 63.84,48.9 54.63,58.11 54.63,58.78 52.4,61.01 52.4,63.22 51.92,63.7 51.92,65.05 50.01,66.95 48.33,66.95 45.97,69.32 43.28,69.32 42.59,70 40.56,70 39.04,71.53 v2(39.04,73.08)
  BOTTOM w0.102: U25.AU14 160.44,84.48 160.44,83.48 160.17,83.21 159.89,83.21 159.68,82.99 159.68,79.16 159.92,78.92 159.92,64.06 173.64,50.34 175.17,50.34 v2(177.25,48.26) 177.25,45.07 178.38,43.94 178.38,27.36 175.79,24.77 175.11,24.77 174.8,24.46 174.43,24.46 174.42,24.45 171.69,24.45 171.53,24.3 171.23,24.3 171.21,24.31 165.6,24.31 164.74,23.44 164.08,23.44 163.46,22.82 157.89,22.82 156.13,21.06 155.22,21.06 153.49,22.78 139.13,22.78 137.06,20.71 118.93,20.71 117.41,22.24 112.92,22.24 110.97,24.18 106.58,24.18 v2(106.32,23.93) ; v2(180.69,153.8) 181.23,154.34 181.23,155.13 180.2,156.15 CN22.16
LAD0_T: length 3.9
  TOP w0.102: U18.26 84.66,23.8 85.67,24.82 R368.2 85.99,25.65 v1(86.13,25.78)
LAD1: length 375.6
  TOP w0.102: v2(39.69,72.86) 39.69,73.04 39.01,73.71 39.01,73.97 38.04,74.93 U11.9 ; R375.1 v2(87.34,23.1)
  IN2 w0.102: v2(87.34,23.1) 87.8,23.56 87.8,24.64 87.24,25.2 87.24,27.23 84.01,30.46 82.92,30.46 70.83,42.55 70.83,43.04 66.42,47.46 66.42,48.24 65.45,49.2 64,49.2 54.96,58.25 54.96,59.75 53.19,61.52 53.19,63.3 52.45,64.03 52.45,64.95 49.5,67.89 47.85,67.89 45.26,70.49 45.26,70.66 44.86,71.06 41.18,71.06 39.69,72.55 v2(39.69,72.86) ; v2(177.56,49.63) 177.43,49.76 177.43,51.27 178.38,52.22 178.38,58.26 176.74,59.89 176.74,63.31 177.96,64.53 177.96,65.36 178.81,66.22 178.81,71.55 179.54,72.28 179.54,75.15 179.54,76.17 182.03,78.66 182.03,83.44 183.54,84.96 183.54,87.89 190.24,94.59 190.24,97.57 189.36,98.46 189.36,100.74 189.04,101.05 188.54,101.05 187.72,101.87 187.55,102.04 187.55,104.65 187.4,104.8 187.4,110.18 188.36,111.13 188.36,111.9 187.04,113.21 187.04,145.14 181.28,150.91 181.28,153.82 180.87,154.23 180.86,154.23 v2(180.64,154.45)
  BOTTOM w0.076: U25.AW12 160.79,83.43 160.33,82.97 160.33,82.22 160.15,82.03
  BOTTOM w0.102: v2(87.34,23.1) 87.79,23.55 v1(88.16,23.55) 88.8,23.55 89.56,22.78 89.56,19.36 90.9,18.01 90.9,16.51 91.29,16.13 91.29,15.27 92.43,14.12 95.28,14.12 96,13.4 96.34,13.06 102.84,13.06 104.67,14.88 104.67,18.06 104.67,18.57 106.86,20.76 106.86,20.79 108,21.93 108.54,21.93 116.7,21.93 118.13,20.5 118.72,20.5 118.81,20.41 137.83,20.41 139.9,22.48 153.36,22.48 155.09,20.75 156.26,20.75 158.02,22.51 163.58,22.51 164.21,23.14 164.86,23.14 165.73,24.01 171.22,24.01 171.31,24.09 171.62,24.09 171.77,24.25 174.51,24.25 174.52,24.26 175.03,24.26 175.23,24.46 175.92,24.46 178.69,27.23 178.69,44.07 177.68,45.07 177.68,48.45 177.37,48.77 177.37,49.25 177.56,49.44 v2(177.56,49.63) 176.5,49.63 175.41,50.72 173.69,50.72 160.22,64.19 160.22,79.05 159.94,79.32 159.94,81.82 160.15,82.03 ; v2(180.64,154.45) 180.74,154.56 180.74,155.18 180.02,155.9 179.76,155.9 179.4,156.25 CN22.14
LAD1_T: length 4
  TOP w0.102: R375.2 85.32,21.85 U18.23 82.58,21.85 v2(82.37,21.64)
LAD2: length 378.7
  TOP w0.102: v2(40.38,73.39) 39.77,73.39 39.39,73.76 39.39,74.09 38.15,75.33 U11.8 ; v2(88.24,19.1) 88.24,19.2 87.88,19.56 86.85,19.56 R394.1
  IN2 w0.102: v2(40.38,73.39) 41.34,73.39 43.02,71.71 47.24,71.71 49.43,69.52 49.43,68.83 53.07,65.2 53.07,64.28 53.8,63.55 53.8,61.77 55.65,59.92 55.65,58.42 64.26,49.81 67.13,49.81 75.59,41.35 75.59,38.66 83.15,31.09 84.25,31.09 84.53,30.81 84.53,30.81 87.85,27.49 87.85,25.64 89.08,24.41 89.08,21.82 88.34,21.08 88.34,19.2 v2(88.24,19.1) ; v2(177.81,49.02) 177.99,49.2 177.99,49.84 177.73,50.09 177.73,51.14 178.73,52.14 178.73,58.34 177.05,60.02 177.05,63.19 178.26,64.4 178.26,65.23 179.84,66.81 179.84,75.27 179.84,76.05 182.33,78.54 182.33,83.32 183.84,84.83 183.84,87.76 190.55,94.46 190.55,97.73 189.66,98.62 189.66,100.86 189.16,101.36 188.66,101.36 187.86,102.17 187.86,104.77 187.7,104.93 187.7,110.05 188.66,111.01 188.66,112.02 187.35,113.33 187.35,145.27 181.58,151.04 181.58,154.12 180.71,154.99 v2(180.25,154.99)
  BOTTOM w0.102: v2(180.25,154.99) 180.25,155.24 179.9,155.59 179.63,155.59 179.32,155.9 179.02,155.9 178.6,156.32 CN22.12 ; v2(88.24,19.1) 88.29,19.05 88.29,18.62 90.98,15.93 90.98,15.14 92.31,13.81 95.15,13.81 95.7,13.27 96.21,12.75 102.97,12.75 104.98,14.76 104.98,18.44 107.17,20.63 107.17,20.67 108.13,21.63 116.24,21.63 117.77,20.1 137.95,20.1 140.02,22.17 153.24,22.17 154.96,20.45 156.39,20.45 158.15,22.21 163.71,22.21 164.34,22.83 164.99,22.83 165.85,23.7 171.35,23.7 171.54,23.89 171.7,23.89 171.84,24.03 175.13,24.03 175.21,24.11 176,24.11 178.99,27.1 178.99,44.19 177.99,45.2 177.99,48.84 v2(177.81,49.02) 177.99,49.2 177.99,49.82 177.72,50.09 176.73,50.09 175.79,51.03 173.81,51.03 160.53,64.32 160.53,79.17 160.25,79.45 160.25,81.71 160.79,82.26 U25.AY12
LAD2_T: length 2.6
  TOP w0.102: R394.2 85.57,19.9 v2(84.73,19.9) U18.20
LAD3: length 381.1
  TOP w0.102: v2(39.9,73.86) 39.9,74.04 38.31,75.64 37.62,75.64 37.52,75.73 U11.7 ; R399.1 86.82,17.25 88.5,17.25 88.9,16.85 v2(88.9,16.79)
  IN2 w0.102: v2(179.71,154.54) 179.71,155.07 180.11,155.46 180.67,155.46 181.89,154.24 181.89,151.16 187.66,145.39 187.66,113.46 188.97,112.15 188.97,110.88 188.01,109.93 188.01,105.05 188.16,104.9 188.16,104.8 189.03,103.94 189.03,101.93 189.96,100.99 189.96,98.78 190.85,97.89 190.85,94.29 184.15,87.58 184.15,84.7 182.64,83.19 182.64,78.41 180.15,75.92 180.15,75.4 180.15,66.69 178.57,65.11 178.57,64.27 177.35,63.06 177.35,60.15 179.04,58.46 179.04,51.82 v2(178.17,50.95) ; v2(88.9,16.79) 88.9,17.07 89.38,17.55 89.38,24.53 88.16,25.76 88.16,27.62 84.38,31.39 83.28,31.39 75.89,38.78 75.89,41.48 67.26,50.12 65.1,50.12 65.09,50.12 64.38,50.12 56.16,58.34 56.16,59.84 54.1,61.9 54.1,63.68 53.37,64.41 53.37,65.35 49.78,68.94 49.78,69.6 47.37,72.01 43.15,72.01 41.3,73.86 v2(39.9,73.86)
  BOTTOM w0.076: 161.02,81.38 161.25,81.61 161.25,82 161.25,82 161.25,82.75 161.25,82.75 161.25,83.02 161.25,83.03 161.25,83.25 161.53,83.54 U25.AW11
  BOTTOM w0.102: v2(88.9,16.79) 88.92,16.79 89.69,16.03 v1(89.69,15.93) 90.37,15.24 90.37,14.89 92.05,13.2 94.9,13.2 95.09,13.02 95.09,13.02 95.96,12.14 103.22,12.14 105.59,14.5 105.59,18.19 107.78,20.38 107.78,20.41 108.38,21.02 115.68,21.02 117.11,19.58 117.42,19.58 117.51,19.49 138.2,19.49 139.41,20.7 153.85,20.7 154.71,19.84 156.64,19.84 158.4,21.6 163.54,21.6 163.54,21.6 163.96,21.6 164.59,22.23 165.24,22.23 166.11,23.09 171.63,23.09 172.03,23.5 176.25,23.5 179.6,26.85 179.6,44.45 178.6,45.45 178.6,50.52 v2(178.17,50.95) 176.81,50.95 176.12,51.64 174.07,51.64 161.56,64.14 161.56,73.79 161.14,74.22 161.14,79.68 161.02,79.79 161.02,81.38 ; CN22.10 177.8,156.12 178.43,155.5 179.22,155.5 179.71,155.01 v2(179.71,154.54)
LAD3_T: length 3.2
  TOP w0.102: R399.2 85.74,16.94 v2(85.11,16.94) 85.11,17.45 84.61,17.95 U18.17
LAN_AMBLED: length 6.5
  TOP w0.508: CN21.11 16.54,175.56 v1(16.91,175.18) C28.2 R21.2
LAN_AMBLED#: length 81.3
  TOP w0.127: v2(21.97,109.32) 22.05,109.4 22.05,111.37 v2(21.64,111.78) 21.64,112.19 22.05,112.6 22.05,114.07 22.28,114.3 U8.27
  IN2 w0.14: v2(21.97,109.32) 21.97,109.42 21.61,109.78 20.09,109.78 18.48,108.17 16.11,108.17 15.31,108.97 15.31,164.31 16.08,165.07 16.08,172.72 15.53,173.27 CN21.12
LAN_CLKRQ: length 3.8
  TOP w0.127: R142.2 24.08,121.97 23.08,120.98 v1(23.08,120.75) U8.12
LAN_DISABLE#: length 14
  TOP w0.127: v3(164.3,89.26) 164.73,89.68 165.28,89.68 165.28,89.68 166.68,89.68 168.24,91.25 170.85,91.25 172.24,92.63 172.24,93.75 173.4,94.91 R169.1
  BOTTOM w0.102: v3(164.3,89.26) 164.1,89.06 164.05,89.06 163.86,88.86 163.86,88.6 163.92,88.54 163.92,88.35 U25.AM7
LAN_MCTG0: length 3.5
  TOP w0.127: v1(15.15,154.8) 15.52,155.17 15.52,155.79 R119.2
  TOP w0.508: U6.7 16.41,155.88 16.4,155.87 15.6,155.87 R119.2
LAN_MCTG1: length 3.5
  TOP w0.127: v1(15.26,163.31) 15.57,163 R101.2
  TOP w0.381: U6.2 16.03,162.23 16.03,162.24 R101.2
LAN_MCTG2: length 3.3
  TOP w0.127: v1(15.52,133.78) 15.75,134.01 R140.2
  TOP w0.508: U7.7 15.77,134.92 R140.2
LAN_MCTG3: length 3.3
  TOP w0.127: R131.2 15.64,141.39 v1(15.64,142.42)
  TOP w0.508: R131.2 15.76,141.27 U7.2
LAN_POWER: length 60.6
  TOP w0.127: U11.112 44.8,78.06 46.56,76.29 46.56,73.27 47.17,72.67 47.17,68.48 48.23,67.41 v2(48.52,67.41) ; PR135.1 61.85,28.75 61.24,29.36 v2(60.98,29.36)
  IN1 w0.14: v2(60.98,29.36) 60.8,29.55 60.8,51.54 57.21,55.12 57.21,57.34 53.55,61 53.27,61.28 53.27,63.1 52.83,63.55 52.36,64.01 52.36,65.52 50.6,67.28 48.65,67.28 v2(48.52,67.41)
LAN_WLED: length 9
  TOP w0.127: R444.2 18.18,169.71 v1(18.18,169.72)
  TOP w0.508: CN21.9 15.26,164.13 18.18,167.05 C614.2 R444.2
LAN_WLED#: length 65.4
  TOP w0.127: v2(21.49,106.86) 21.94,107.32 21.94,108.18 21.49,108.64 R156.2 21.49,109.17 v2(21.33,109.32) 21.49,109.47 R157.2
  IN2 w0.14: CN21.10 15.01,159.91 15.01,108.41 15.92,107.49 18.57,107.49 20.39,109.32 v2(21.33,109.32)
LAN_XTAL1: length 6.6
  TOP w0.127: R155.1 22.56,109.7 C262.2 22.82,109.7 23.77,108.74 Y2.1 23.77,108.26 23.26,107.75 22.38,107.75 22.25,107.62 22.25,106.82 v2(22.71,106.36)
LAN_XTAL25_IN: length 60
  TOP w0.127: R159.2 22.5,103.05 22.5,100.89 v2(23.26,100.13) ; v2(65.66,92.14) 65.66,90.62 v1(67.6,88.67) C319.2 68.48,86.78 R208.1
  IN1 w0.14: v2(65.66,92.14) 56.66,92.14 55.98,91.45 52.99,91.45 52.52,91.92 46.97,91.92 46.8,91.75 41.65,91.75 41.39,92.01 39.01,92.01 38.36,92.65 34.04,92.65 33.17,93.52 32.08,93.52 26.87,98.73 26.87,99.06 25.81,100.13 v2(23.26,100.13)
LAN_XTAL25_IN_R: length 4.2
  TOP w0.127: U9.6 69.2,83.65 69.39,83.84 69.39,84.42 68.55,85.26 R208.2 68.48,84.53 v1(68.15,84.2)
LANRSET: length 3.4
  TOP w0.127: U8.31 23.88,114.08 v2(24.53,113.44) 24.64,113.44 25.62,112.45 R154.2
LED1: length 4.6
  TOP w0.127: R157.1 21.13,111.16 21.13,112.89 v2(21.32,113.08) 21.74,113.5 21.74,114.12 21.88,114.26 U8.26
LED1_21232747: length 106.4
  TOP w0.127: v2(31.55,97.61) 32.59,98.66 34.86,98.66 36.79,100.58 37.95,100.58 38.53,101.17 40.23,101.17 v1(40.64,100.76) 41.04,100.36 41.04,98.76 PQ13.3 43.67,97.26 PR63.2 43.8,96.45 43.47,96.13 PQ17.4
  BOTTOM w0.127: CN20.7 28.8,176.95 27.98,176.14 PC45.2 27.98,175.19 30.31,172.86 30.31,151.6 29.8,151.09 29.8,125.85 26.82,122.87 26.82,113.84 27.38,113.28 27.38,101.78 v2(31.55,97.61)
LED2: length 104.3
  TOP w0.127: PR67.2 38.01,94.9 PQ16.4 38.01,95.95 37.84,96.11 37.84,97.26 PQ12.3 39.24,99.31 37.86,97.93 36.68,97.93 36.61,97.85 36.18,97.85 35.63,98.41 33.53,98.41 v2(32.74,97.61)
  BOTTOM w0.127: v2(32.74,97.61) 27.63,102.72 27.63,113.39 27.07,113.95 27.07,122.77 30.05,125.74 30.05,150.98 30.57,151.5 30.57,174.37 30.75,174.55 30.75,175.99 PC46.2 30.17,176.57 v2(30.17,177.53) 29.74,177.97 29.74,181.07 CN20.8
LFRAME#: length 384.5
  TOP w0.102: v2(88.65,23) 88.38,23 EC50.1 87.91,22.65 R384.1 ; v2(40.41,72.7) 40.87,73.15 40.87,73.51 38.44,75.94 37.78,75.94 37.59,76.13 U11.6
  IN2 w0.102: v2(178.17,50.32) 179.34,51.49 179.34,58.85 177.66,60.53 177.66,62.93 178.87,64.15 178.87,64.98 180.45,66.56 180.45,75.53 180.45,75.79 182.94,78.28 182.94,83.07 184.45,84.58 184.45,87.45 189.63,92.63 190.78,92.63 191.16,93.02 191.16,98.02 190.27,98.91 190.27,101.12 189.33,102.06 189.33,104.06 188.47,104.93 188.47,105.03 188.31,105.18 188.31,109.8 189.27,110.76 189.27,119.9 188.22,120.95 187.96,121.21 187.96,145.52 182.26,151.22 182.26,155.26 181.75,155.77 179.75,155.77 v2(178.97,154.99) ; v2(40.41,72.7) 40.69,72.7 42.02,71.37 47.15,71.37 49.1,69.42 49.1,68.73 52.75,65.08 52.75,64.16 53.49,63.42 53.49,61.65 55.26,59.87 55.26,58.38 64.13,49.51 67,49.51 75.28,41.22 75.28,38.53 83.03,30.78 83.66,30.78 84.12,30.79 87.55,27.36 87.55,25.33 88.11,24.77 88.11,23.45 v2(88.65,23)
  BOTTOM w0.076: U25.AV12 161.09,83.86 161.09,83.09 161.08,83.09 161.08,82.68 161.09,82.68 161.09,82.07 160.6,81.59 160.6,79.65
  BOTTOM w0.102: 160.6,79.65 160.83,79.43 160.83,64.44 173.94,51.33 175.94,51.33 176.83,50.44 178.04,50.44 v2(178.17,50.32) 178.29,50.19 178.29,45.32 179.3,44.32 179.3,26.98 176.12,23.8 171.91,23.8 171.5,23.4 165.98,23.4 165.12,22.53 164.46,22.53 163.84,21.9 158.27,21.9 156.51,20.14 154.84,20.14 153.9,21.08 139.36,21.08 138.08,19.8 117.64,19.8 117.55,19.89 117.24,19.89 115.8,21.32 108.26,21.32 107.47,20.54 107.47,20.51 105.28,18.31 105.28,14.63 103.1,12.45 96.09,12.45 95.39,13.14 95.03,13.51 92.18,13.51 90.68,15.01 90.68,15.67 89.28,17.07 89.28,17.12 89.03,17.37 88.97,17.37 87.81,18.54 87.81,20.14 88.11,20.45 v1(88.11,21.03) 88.11,22.46 v2(88.65,23) ; CN22.8 177,156.32 177.8,155.52 177.97,155.52 178.5,154.99 v2(178.97,154.99)
LFRAME#_T: length 2.5
  TOP w0.102: R384.2 85.58,21.51 v2(85.37,21.31) 85.27,21.2 U18.22
LID_EC#: length 112.8
  TOP w0.127: v2(32.15,176.07) 32.15,176.58 32.4,176.83 C58.1 ; U11.123 40.4,80.6 39.93,81.08 39.27,81.08 37.83,82.51 37.83,83.47 37.5,83.8 36.93,83.8 36.64,84.1 36.27,84.1 36.03,84.33 36.03,86.68 36.26,86.91 R200.2 36.79,86.91 36.96,87.07 36.96,87.96 36.6,88.32 35.51,88.32 v2(35.2,88.01) ; v1(33.68,176.71) 33.56,176.83 C58.1 ; C58.1 32.66,175.95 32.8,175.82 CN5.3
  BOTTOM w0.127: v2(35.2,88.01) 35.2,92.94 36.82,94.55 36.82,98.48 27.89,107.41 27.89,113.49 27.33,114.05 27.33,122.66 30.3,125.64 30.3,150.88 30.82,151.39 30.82,173.6 32.15,174.93 v2(32.15,176.07)
LINEOUT_L: length 2.6
  BOTTOM w0.254: v2(192.76,13.47) 193.09,13.8 R614.2 193.63,14.33 194.09,14.79 U28.14
LINEOUT_L_C: length 11.7
  TOP w0.254: CN14.3 197.68,16.25 196.34,14.91 v1(195.35,14.91) v2(191.8,14.91)
  BOTTOM w0.254: R614.1 193.58,13.02 193.48,12.92 191.89,12.92 R616.1 C805.2 v2(191.8,14.91)
LINEOUT_R: length 2.8
  BOTTOM w0.254: U28.11 195.59,14.93 195.98,14.54 196.11,14.54 R615.2 195.97,13.9 v2(195.89,13.98)
LINEOUT_R_C: length 6.1
  TOP w0.254: CN14.2 198.16,15.75 197.86,15.46 v2(197.86,14.66)
  BOTTOM w0.254: v2(197.86,14.66) 197.88,14.64 C806.2 R617.1 196.86,13.01 R615.1 196.29,13.12 v2(195.85,12.68)
LM_EN: length 220.3
  TOP w0.127: CN11.5 200.33,54.05 200.94,54.66 200.94,56.95 200.56,57.33 198.14,57.33 195.7,54.88 192.4,54.88 191.23,53.72 189.84,53.72 189.63,53.52 183.25,53.52 181.67,55.1 181.67,58.06 v1(181.51,58.22) 181,58.22 178.77,60.45 v2(178.77,61.18) ; v2(54.19,64.77) R8559.2
  IN2 w0.14: v2(178.77,61.18) 179.67,60.28 179.67,45.58 180.44,44.81 180.44,42.29 179.29,41.15 179.29,34.98 177.39,33.08 177.39,32.23 176.27,31.12 176.27,27.7 173.8,25.22 169.2,25.22 166.1,22.13 152.99,22.13 152.99,22.13 127.39,22.13 126.67,21.41 119.63,21.41 119.62,21.4 119.24,21.4 119.23,21.41 111.12,21.41 100.24,32.28 99.64,32.28 99.03,32.89 96.32,32.89 95.12,34.09 95.12,35.66 92.93,37.85 90.72,37.85 87.98,40.59 87.98,44.06 83.01,49.03 83.01,51.76 79.14,55.63 79.14,56.49 73.05,62.59 v2(73.05,63.17)
  BOTTOM w0.127: v2(73.05,63.17) 71.4,61.52 68.35,61.52 66.75,63.12 63.32,63.12 61.85,64.59 58.55,64.59 57.75,65.39 54.81,65.39 v2(54.19,64.77)
LVDS_BLON1: length 5.6
  TOP w0.127: 42.57,165.67 R1.2 41.55,166.6 v1(41.43,166.73) ; 42.57,165.67 R2.1 ; 42.57,165.67 42.57,166.18 42.69,166.29 R4.1 R5.1
M_A_A0: length 60.9
  IN2 w0.089: 144.87,78.8 145.31,79.24 145.31,81.84 145.49,82.02 145.49,84.09 v2(145.94,84.54)
  IN2 w0.216: 144.87,78.8 143.51,77.44 143.51,75.44 143.32,75.25 143.32,47.03 143.39,46.95 143.39,45 143.19,44.79 143.19,38.98 143.44,38.73 143.44,35.38 142.96,34.9 142.96,29.26 v4(143.24,28.97)
  BOTTOM w0.089: U25.AU36 146.06,84.54 v2(145.94,84.54)
  BOTTOM w0.191: JDIM2.98 143.85,28.39 143.26,28.97 v4(143.24,28.97)
M_A_A1: length 62.9
  IN2 w0.089: v2(145.96,81.92) 145.64,81.92 145.49,81.77 145.49,78.72 145.14,78.36
  IN2 w0.216: v4(143.59,32.84) 143.59,34.7 144.58,35.68 144.58,37.4 144.76,37.58 144.76,38.15 143.71,39.19 143.71,44.58 143.91,44.78 143.91,47.17 143.91,47.17 143.91,54.68 144.09,54.85 144.64,54.85 144.83,55.04 144.83,55.31 144.64,55.5 144.1,55.5 143.91,55.69 143.91,55.96 144.1,56.15 144.91,56.15 145.1,56.34 145.1,56.61 144.91,56.8 144.1,56.8 143.91,56.99 143.91,57.26 144.1,57.45 144.91,57.45 145.1,57.64 145.1,57.9 144.91,58.09 144.08,58.09 143.89,58.28 143.89,58.55 144.08,58.74 144.91,58.74 145.1,58.93 145.1,59.2 144.91,59.39 144.11,59.39 143.92,59.58 143.92,59.85 144.11,60.04 144.88,60.04 145.07,60.23 145.07,60.49 144.88,60.68 144.03,60.68 143.84,60.87 143.84,74.55 144.12,74.83 144.12,77.34 145.14,78.36
  BOTTOM w0.089: v2(145.96,81.92) 145.49,82.39 U25.AY37
  BOTTOM w0.191: v4(143.59,32.84) 143.55,32.88 JDIM2.97
M_A_A2: length 63.4
  IN2 w0.089: v2(144.87,85.67) 144.96,85.58 144.96,82.24 144.78,82.06 144.78,79.8 143.67,78.7 143.13,78.7 142.07,77.63 142.07,74.37 141.51,73.81 141.51,72.93
  IN2 w0.216: 141.51,72.93 141.51,58.57 140.85,57.92 140.85,45.17 141.36,44.66 141.36,43.27 141.17,43.08 141.17,38.8 141.27,38.69 141.27,30.25 142.34,29.18 142.34,28.06 v4(142.75,27.65)
  BOTTOM w0.089: v2(144.87,85.67) 145.19,86 U25.AR38
  BOTTOM w0.191: JDIM2.96 143.25,27.15 v4(142.75,27.65)
M_A_A3: length 63.4
  IN2 w0.089: v2(145.82,86.46) 145.44,86.07 145.44,84.86 145.13,84.55 145.13,82.17 144.96,81.99 144.96,79.68 143.79,78.52 143.21,78.52 142.37,77.68 142.37,74.34 142.03,74 142.03,72.73
  IN2 w0.216: v4(142.29,30.75) 142.21,30.75 141.79,31.16 141.79,37.12 142.4,37.72 142.4,38.3 141.69,39 141.69,42.82 141.88,43.02 141.88,46.21 141.62,46.47 141.62,48.41 141.37,48.66 141.37,57.42 142.03,58.08 142.03,72.73
  BOTTOM w0.089: U25.AP36 146.01,86.65 v2(145.82,86.46)
  BOTTOM w0.191: v4(142.29,30.75) 143,31.46 143,34.2 JDIM2.95
M_A_A4: length 62.3
  IN2 w0.089: 140.99,72.91 140.99,73.75 141.77,74.54 141.77,77.59 143.05,78.87 143.6,78.87 144.6,79.88 144.6,82.14 144.78,82.32 144.78,84.09 144.35,84.51 v2(144.33,84.51)
  IN2 w0.216: v4(141.47,29.18) 141.47,29.21 140.75,29.94 140.75,38.48 140.75,38.49 140.61,38.63 140.61,43.28 140.79,43.46 140.79,44.5 140.33,44.96 140.33,58.3 140.99,58.96 140.99,72.91
  BOTTOM w0.089: v2(144.33,84.51) 144.65,84.84 U25.AU39
  BOTTOM w0.191: v4(141.47,29.18) 142.05,28.6 JDIM2.92
M_A_A5: length 62.4
  IN2 w0.089: v2(145.85,85.82) 145.62,85.6 145.62,84.79 145.31,84.48 145.31,82.1 145.13,81.92 145.13,79.6 143.88,78.34 143.28,78.34 142.55,77.61 142.55,72.89
  IN2 w0.216: 142.55,72.89 142.55,57.61 142.36,57.42 142.11,57.42 141.92,57.23 141.92,56.96 142.11,56.77 142.36,56.77 142.55,56.58 142.55,56.29 142.38,56.13 142.16,56.13 141.97,55.94 141.97,55.67 142.16,55.48 142.38,55.48 142.57,55.29 142.57,55.02 142.38,54.83 142.16,54.83 141.97,54.64 141.97,54.37 142.16,54.18 142.38,54.18 142.57,53.99 142.57,53.72 142.38,53.54 142.16,53.54 141.97,53.35 141.97,53.08 142.16,52.89 142.38,52.89 142.57,52.7 142.57,52.43 142.38,52.24 142.16,52.24 141.97,52.05 141.97,48.94 142.16,48.76 142.16,46.67 142.41,46.42 142.41,44.71 142.67,44.45 142.67,38.76 142.92,38.51 142.92,35.6 142.31,35 v4(142.31,32.17)
  BOTTOM w0.089: U25.AR36 146.02,86 v2(145.85,85.82)
  BOTTOM w0.191: v4(142.31,32.17) 141.75,32.73 JDIM2.91
M_A_A6: length 63.5
  IN2 w0.089: v2(144.03,80.76) 144.42,80.36 144.42,79.95 143.52,79.05 142.9,79.05 141.6,77.74 141.6,74.7 140.47,73.57 140.47,72.88
  IN2 w0.216: 140.47,72.88 140.47,59.18 139.74,58.44 139.74,43.42 140.09,43.06 140.09,38.41 140.22,38.28 140.22,27.13 140.55,26.81 141.18,26.81 141.47,27.1 v4(141.47,27.58)
  BOTTOM w0.076: v2(144.03,80.76) 143.7,81.09 143.62,81.16 143.62,83.89 U25.AV40
  BOTTOM w0.191: JDIM2.90 141.45,27.56 v4(141.47,27.58)
M_A_A7: length 62.8
  IN2 w0.089: 138.87,72.84 138.87,73.2 140.11,74.44 140.11,77.37 142.33,79.59 143.08,79.59 143.44,79.95 143.44,82.3 144.35,83.21 v2(144.33,83.21)
  IN2 w0.216: 138.87,72.84 138.87,70.79 138.31,70.23 138.31,63.57 138.11,63.37 138.11,57.73 136.96,56.58 136.96,54.34 137.71,53.59 137.71,47.44 137.51,47.24 137.51,40.59 138.17,39.94 138.17,33.41 138.53,33.05 138.53,31.85 139.11,31.26 139.11,31.01 139.65,30.47 v4(139.65,29.24)
  BOTTOM w0.089: U25.AW39 144.65,83.54 v2(144.33,83.21)
  BOTTOM w0.191: JDIM2.86 140.25,28.64 v4(139.65,29.24)
M_A_A8: length 62.3
  IN2 w0.089: v2(144.03,81.39) 143.62,80.98 143.62,79.87 143.16,79.42 142.7,79.42 140.47,77.19 140.47,74.36 139.39,73.28 139.39,73.03
  IN2 w0.216: 139.39,73.03 139.39,70.58 138.83,70.01 138.83,63.02 138.63,62.83 138.63,56.61 138.44,56.42 137.69,56.42 137.5,56.23 137.5,55.96 137.69,55.77 138.44,55.77 138.63,55.58 138.63,55.32 138.44,55.13 137.67,55.13 137.48,54.94 137.48,54.64 137.64,54.48 138.44,54.48 138.63,54.29 138.63,43.19 138.49,43.05 138.49,40.35 138.69,40.15 138.69,33.62 139.16,33.15 139.16,31.95 139.7,31.41 v4(139.7,31.26)
  BOTTOM w0.089: U25.AY39 144.77,82.86 144.77,82.13 v2(144.03,81.39)
  BOTTOM w0.191: JDIM2.89 141.15,32.7 v4(139.7,31.26)
M_A_A9: length 63.4
  IN2 w0.089: v2(144.02,80.11) 144.02,79.89 143.36,79.24 142.78,79.24 141.39,77.85 141.39,74.99 139.91,73.51 139.91,72.66
  IN2 w0.216: v4(139.7,32.78) 139.7,33.34 139.21,33.84 139.21,40.37 139.01,40.57 139.01,42.82 139.15,42.95 139.15,59.49 139.34,59.68 139.76,59.68 139.95,59.87 139.95,60.14 139.76,60.33 139.34,60.33 139.15,60.52 139.15,60.79 139.34,60.98 139.76,60.98 139.95,61.17 139.95,61.44 139.76,61.63 139.34,61.63 139.15,61.82 139.15,62.09 139.34,62.28 139.76,62.28 139.95,62.47 139.95,62.73 139.76,62.92 139.55,62.92 139.36,63.11 139.36,63.38 139.55,63.57 139.76,63.57 139.95,63.76 139.95,64.03 139.76,64.22 139.55,64.22 139.36,64.41 139.36,64.68 139.55,64.87 139.76,64.87 139.95,65.06 139.95,65.32 139.76,65.51 139.55,65.51 139.36,65.7 139.36,65.97 139.55,66.16 139.76,66.16 139.95,66.35 139.95,66.62 139.76,66.81 139.54,66.81 139.35,67 139.35,67.27 139.54,67.46 139.76,67.46 139.91,67.61 139.91,67.92 139.72,68.1 139.54,68.1 139.35,68.29 139.35,68.56 139.54,68.75 139.72,68.75 139.91,68.94 139.91,69.21 139.72,69.4 139.61,69.4 139.42,69.59 139.42,69.86 139.61,70.05 139.72,70.05 139.91,70.24 139.91,72.66
  BOTTOM w0.076: U25.AU40 143.87,84.63 143.6,84.36 143.6,84.1 143.46,83.96 143.46,80.67 143.94,80.19
  BOTTOM w0.191: 143.94,80.19 v2(144.02,80.11) ; JDIM2.85 139.95,33.03 v4(139.7,32.78)
M_A_A10: length 64.9
  IN2 w0.089: 150.44,72.57 150.44,73.13 148.8,74.76 148.8,84.75 147.74,85.81 v2(147.74,86.23)
  IN2 w0.216: v4(148.8,31.12) 150.16,31.12 150.77,31.72 150.77,38.98 151.75,39.97 151.75,43.24 150.83,44.16 150.83,47.06 151.74,47.96 151.74,52.91 151.95,53.12 151.95,63.1 150.44,64.61 150.44,72.57
  BOTTOM w0.076: U25.AP35 147.32,86.65 v2(147.74,86.23)
  BOTTOM w0.191: v4(148.8,31.12) 148.2,31.12 146.55,32.77 JDIM2.107
M_A_A11: length 62.7
  IN2 w0.089: 138.35,72.69 138.35,73.12 139.92,74.68 139.92,77.47 142.22,79.77 142.94,79.77 143.26,80.09 143.26,82.71 v2(142.76,83.21)
  IN2 w0.216: v4(139.65,27.59) 139.13,28.1 139.13,30.26 138.59,30.8 138.59,31.05 137.95,31.7 137.95,32.79 137.65,33.09 137.65,39.72 136.98,40.39 136.98,47.45 137.19,47.66 137.19,53.37 136.44,54.12 136.44,56.97 137.47,58 137.47,63.65 137.78,63.97 137.78,70.44 138.35,71.01 138.35,72.69
  BOTTOM w0.089: U25.AW41 142.84,83.21 v2(142.76,83.21)
  BOTTOM w0.191: JDIM2.84 v4(139.65,27.59)
M_A_A12: length 62.4
  IN2 w0.089: v2(142.77,84.54) 142.19,83.96 142.19,83.22 142.6,82.8 142.69,82.8 143.08,82.41 143.08,80.22 142.81,79.95 142.14,79.95 139.72,77.53 139.72,74.94 137.83,73.05 137.83,72.87
  IN2 w0.216: 137.83,72.87 137.83,71.23 137.26,70.66 137.26,64.62 136.91,64.27 136.91,58.18 135.92,57.19 135.92,53.91 136.67,53.15 136.67,47.87 136.46,47.66 136.46,40.17 136.9,39.73 136.9,33.1 137.42,32.58 137.42,31.6 v4(137.42,31.59)
  BOTTOM w0.089: v2(142.77,84.54) 143.07,84.84 U25.AU41
  BOTTOM w0.191: v4(137.42,31.59) 138.42,31.59 139.21,32.38 139.21,33.08 139.35,33.22 JDIM2.83
M_A_A13: length 62.2
  IN2 w0.089: 149.65,72.66 149.65,73.44 148.62,74.46 148.62,84.67 148.22,85.07 146.9,85.07 146.81,85.17 v2(146.81,85.64)
  IN2 w0.216: v4(149.96,31.71) 150.23,31.99 150.23,39.18 151.23,40.18 151.23,43.02 150.16,44.09 150.16,47.12 150.5,47.46 150.5,49.94 151.05,50.48 151.05,53.11 151.43,53.5 151.43,62.88 149.65,64.66 149.65,72.66
  BOTTOM w0.089: v2(146.81,85.64) 146.83,85.64 U25.AR35
  BOTTOM w0.191: JDIM2.119 150.15,32.58 150.61,32.12 150.61,31.71 150.4,31.49 150.17,31.49 v4(149.96,31.71)
M_A_A14: length 63.8
  IN2 w0.089: v2(142.64,81.01) 142.24,80.6 142.24,80.58 139.32,77.66 139.32,75.3 137.14,73.12 136.79,72.77 136.79,72.42
  IN2 w0.216: v4(137.93,29.52) 137.93,29.58 136.24,31.27 136.24,32.28 135.86,32.67 135.86,39.3 134.95,40.21 134.95,48.33 135.63,49 135.63,52.72 134.88,53.47 134.88,57.62 135.85,58.59 135.85,65.38 136.22,65.75 136.22,71.09 136.79,71.66 136.79,72.42
  BOTTOM w0.076: v2(142.64,81.01) 142.05,81.6 142.05,83.89 U25.AV42
  BOTTOM w0.191: v4(137.93,29.52) 138.45,28.99 JDIM2.80
M_A_A15: length 64.6
  IN2 w0.089: 137.31,72.42 137.31,72.96 139.5,75.15 139.5,77.59 142.26,80.35 v2(142.64,80.35)
  IN2 w0.216: 137.31,72.42 137.31,71.44 136.74,70.87 136.74,65.19 136.38,64.83 136.38,58.38 135.4,57.4 135.4,53.69 136.15,52.94 136.15,48.79 135.48,48.11 135.48,43.79 135.94,43.33 135.94,39.96 136.38,39.51 136.38,32.88 136.76,32.5 136.76,31.48 138.51,29.74 138.51,28.51 v4(137.9,27.91)
  BOTTOM w0.076: U25.AU42 142.29,84.63 141.88,84.22 141.88,81.11 v2(142.64,80.35)
  BOTTOM w0.191: JDIM2.78 137.85,27.85 v4(137.9,27.91)
M_A_BS#0: length 63
  IN2 w0.089: 147.08,74.89 147.08,76.97 147.48,77.37 v2(147.48,79.86)
  IN2 w0.216: 147.08,74.89 146.59,74.39 146.59,62.59 147.67,61.51 147.67,59.38 147.86,59.19 148.55,59.19 148.74,58.99 148.74,58.72 148.56,58.54 147.86,58.54 147.67,58.35 147.67,58.08 147.86,57.89 148.64,57.89 148.83,57.7 148.83,57.43 148.64,57.24 147.86,57.24 147.67,57.05 147.67,56.78 147.86,56.59 148.64,56.59 148.83,56.41 148.83,56.14 148.64,55.95 147.86,55.95 147.67,55.76 147.67,55.49 147.86,55.3 148.55,55.3 148.74,55.11 148.74,54.84 148.55,54.65 147.86,54.65 147.67,54.46 147.67,53.84 147.03,53.2 147.03,48.29 147.35,47.97 147.35,46.21 146.87,45.74 146.87,39.64 147.62,38.89 147.62,34.12 147.13,33.63 v4(147.13,32.83)
  BOTTOM w0.076: v2(147.48,79.86) 146.61,80.73 146.61,84.14 147.01,84.55 U25.AU35
  BOTTOM w0.191: JDIM2.109 147.15,32.84 v4(147.13,32.83)
