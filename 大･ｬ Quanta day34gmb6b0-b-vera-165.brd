# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB30_RX2+: length 193.5
  TOP w0.127: R329.2 20.51,42.09 20.64,41.96 20.64,41.58 20.77,41.45 21.63,41.45 23.29,43.1 23.29,46.02 24.41,47.14 24.76,47.14 v1(25.3,47.68) 25.82,47.16 26.1,47.16 26.47,47.52 26.47,50.11 30.88,54.53 30.88,57.1 33.04,59.26 33.04,72.79 30.58,75.25 30.58,77.88 30.46,78 30.28,78 29.93,77.65 v2(29.93,77.53)
  IN1 w0.14: v2(29.93,77.53) 29.93,77.65 30.26,77.99 30.54,77.99 31.35,77.18 62.92,77.18 65.09,75.02 72.22,75.02 72.46,75.26 75.21,75.26 75.86,75.91 76.72,75.91 76.99,75.64 79.91,75.64 80.16,75.39 89.94,75.39 90.19,75.64 95.51,75.64 96.3,74.85 102.05,74.85 109.52,82.32 109.52,87.05 119.24,96.77 121.91,96.77 122.54,97.4 123.27,97.4 125.94,100.06 131.44,100.06 132.03,99.46 134.37,99.46 135.88,97.96 136.99,97.96 148.98,97.96 149.14,98.11 149.36,98.34 152.28,98.34 153.68,99.73 154.53,99.73 154.99,100.19 156.42,100.19 156.98,100.75 156.98,101.75 v2(157.17,101.94)
  BOTTOM w0.127: U25.F18 157.69,102.07 157.48,101.85 157.25,101.85 157.17,101.93 v2(157.17,101.94)
USB30_RX2+_C: length 7.4
  TOP w0.127: CN28.6 13.9,40.88 14.04,40.74 14.29,40.74 14.72,41.17 16.53,41.17 v1(17.05,41.69) 17.05,41.44 17.24,41.25 17.52,41.25 17.96,41.69 18.52,41.69 18.92,42.09 R329.1
USB30_RX2-: length 193.5
  TOP w0.127: v2(29.93,78.3) 29.99,78.23 30.55,78.23 30.81,77.97 30.81,75.35 33.27,72.89 33.27,59.16 31.11,57 31.11,54.44 26.69,50.02 26.69,47.42 26.2,46.93 25.82,46.93 v1(25.3,46.41) 24.79,46.91 24.51,46.91 23.52,45.92 23.52,43.01 21.73,41.22 20.69,41.22 20.55,41.07 R330.2
  IN1 w0.14: v2(157.16,102.59) 156.72,102.14 156.72,100.86 156.31,100.46 154.88,100.46 154.42,100 153.57,100 152.17,98.6 149.25,98.6 148.87,98.22 136.88,98.22 135.99,98.22 134.48,99.73 132.14,99.73 131.7,100.17 131.55,100.33 125.83,100.33 123.16,97.66 122.43,97.66 121.8,97.03 119.13,97.03 109.26,87.16 109.26,82.43 101.94,75.11 96.41,75.11 95.62,75.91 90.08,75.91 89.83,75.65 80.27,75.65 80.02,75.91 77.1,75.91 76.83,76.18 75.75,76.18 75.1,75.53 72.35,75.53 72.11,75.28 65.2,75.28 63.03,77.45 31.46,77.45 30.65,78.26 29.96,78.26 v2(29.93,78.3)
  BOTTOM w0.127: U25.E18 157.47,102.9 v2(157.16,102.59)
USB30_RX2-_C: length 7.4
  TOP w0.127: CN28.5 13.9,40.39 14.02,40.51 14.39,40.51 14.82,40.95 16.53,40.95 v1(17.05,40.42) 17.05,40.83 17.24,41.02 17.61,41.02 18.06,41.47 18.58,41.47 18.98,41.07 R330.1
USB30_RX3+: length 119.6
  TOP w0.127: v2(193.69,32.85) 193.69,33.03 193.5,33.22 193.33,33.22 193.16,33.05 192.74,33.05 192.56,32.87 C487.1
  IN1 w0.076: 166.01,100.11 166,100.11 165.92,100.19 165.24,100.19 165.14,100.09 164.57,100.09 164.37,100.28 163.32,100.28 162.96,99.92 160.04,99.92 159.56,100.41 159.56,102.43 159.4,102.59 159.26,102.59 v2(159.13,102.46)
  IN1 w0.14: 166.01,100.11 167.26,100.11 167.77,100.61 168.81,100.61 170.02,101.82 180.66,101.82 181.38,102.54 182.48,102.54 182.76,102.26 189.15,102.26 190.42,100.99 190.42,99.72 191.02,99.12 191.02,92.49 189.52,91 187.87,91 185.64,88.76 185.64,85.25 186.81,84.08 186.81,82.27 187.77,81.32 187.78,81.3 190.64,78.44 191.06,78.02 192.55,78.02 192.55,78.02 194.08,78.02 194.37,77.74 194.37,71.88 194.37,60.95 195.45,59.87 195.45,58.45 196.49,57.41 196.49,49.91 194.72,48.14 194.72,43.06 193.3,41.64 193.3,37.32 193.31,37.21 192.43,36.34 192.43,33.45 192.54,33.35 192.69,33.2 193.44,33.2 193.69,32.95 v2(193.69,32.85)
  BOTTOM w0.076: v2(159.13,102.46) 159.13,102.46 159.03,102.57 158.55,102.57 158.4,102.71 158.28,102.71 158.19,102.62 158.19,102.49 158.2,102.48 158.44,102.25 U25.F17
USB30_RX3+_C: length 5.3
  TOP w0.127: U15.22 189.77,31.4 189.63,31.54 189.63,31.94 189.76,32.07 v1(190.15,32.07) 189.63,32.59 189.63,32.71 190.13,33.21 191.63,33.21 191.78,33.05 C487.2
USB30_RX3+_DC: length 15.9
  TOP w0.127: U15.9 189.77,26.36 189.49,26.09 189.49,25.97 189.84,25.63 189.84,25.37 190.22,24.99 190.22,24.12 190.38,23.97 190.54,23.97 v1(191.31,24.74) 191.84,24.21 191.96,24.21 192.47,23.7 195.2,23.7 195.48,23.98 196.83,23.98 197.97,25.11 197.97,27.37 198.21,27.61 198.4,27.61 198.54,27.75 CN14.26
USB30_RX3-: length 119.6
  TOP w0.127: v2(193.69,33.67) 193.47,33.45 193.24,33.45 193.06,33.27 192.73,33.27 192.56,33.44 C483.1
  IN1 w0.076: v3(158.19,101.93) 158.39,102.12 158.39,102.29 158.98,102.87 159.35,102.87 159.73,102.49 159.73,100.48 160.11,100.09 162.9,100.09 163.25,100.44 164.44,100.44 164.63,100.25 165.07,100.25 165.17,100.36 165.97,100.36 165.99,100.37 166.01,100.37
  IN1 w0.14: v2(193.69,33.67) 193.48,33.46 192.8,33.46 192.7,33.56 192.7,36.23 193.57,37.1 193.57,37.43 193.57,41.53 194.99,42.95 194.99,48.03 196.76,49.8 196.76,57.52 195.72,58.56 195.72,59.98 194.63,61.06 194.63,71.77 194.63,77.88 194.23,78.29 192.44,78.29 191.17,78.29 190.9,78.55 190.9,78.56 187.95,81.51 187.08,82.38 187.08,84.19 185.9,85.36 185.9,88.65 187.98,90.73 189.63,90.73 191.29,92.38 191.29,99.23 190.69,99.83 190.69,101.1 189.26,102.53 182.87,102.53 182.59,102.81 181.27,102.81 180.55,102.09 169.91,102.09 168.7,100.88 167.65,100.88 167.15,100.37 166.01,100.37
  BOTTOM w0.076: U25.G17 158.53,101.6 v3(158.19,101.93)
USB30_RX3-_C: length 5.4
  TOP w0.127: C483.2 191.52,33.44 190.04,33.44 189.4,32.81 189.4,32.59 v1(188.88,32.07) 189.25,32.07 189.4,31.92 189.4,31.54 189.27,31.4 U15.23
USB30_RX3-_DC: length 15.9
  TOP w0.127: U15.8 189.27,25.88 189.61,25.53 189.61,25.28 189.99,24.9 189.99,24.03 190.28,23.74 191.04,23.74 v1(191.31,23.47) 191.82,23.98 191.87,23.98 192.38,23.47 195.3,23.47 195.58,23.75 196.93,23.75 198.19,25.02 198.19,27.28 198.3,27.39 198.42,27.39 198.55,27.25 CN14.25
USB30_RX4+: length 123.9
  TOP w0.076: v2(159.12,101.18) 158.64,101.67 158.56,101.74 158.56,103.11 158.59,103.13 158.59,103.76 158.56,103.8
  TOP w0.127: R8547.2 74.02,163.3 74.26,163.3 v2(74.52,163.03) 74.79,163.3 76.31,163.3 76.5,163.1 76.52,163.1 v1(76.52,162.43) 77.27,162.43 77.7,162 83.54,162 104.02,141.52 104.02,141.47 112.73,132.77 129.65,132.77 141.28,121.13 153.26,121.13 154.86,119.53 155.05,119.53 160.27,114.31 160.27,106.06 158.61,104.4 158.61,104.4 158.56,104.35 158.56,103.8
  BOTTOM w0.076: v2(159.12,101.18) 159.54,101.6 U25.G15
  BOTTOM w0.127: C8782.1 74.02,163.3 74.26,163.3 v2(74.52,163.03)
USB30_RX4-: length 123.9
  TOP w0.076: v2(159.12,101.82) 159.03,101.73 158.88,101.73 158.73,101.87 158.73,103.04 158.76,103.07 158.76,103.76 158.79,103.8
  TOP w0.127: 158.79,103.8 158.79,104.26 160.5,105.97 160.5,114.4 155.14,119.76 154.95,119.76 153.35,121.36 141.37,121.36 129.74,132.99 112.83,132.99 104.25,141.57 104.25,141.61 83.63,162.23 77.8,162.23 77.42,162.61 v1(77.42,163.33) 76.6,163.33 76.4,163.53 74.79,163.53 v2(74.52,163.79) 74.26,163.53 74.02,163.53 R8546.2
  BOTTOM w0.076: v2(159.12,101.82) 159.55,102.25 U25.F15
  BOTTOM w0.127: v2(74.52,163.79) 74.26,163.53 74.02,163.53 C8746.1
USB30_TX1+: length 175.5
  TOP w0.127: v2(30.01,83.36) 30.01,83.15 29.89,83.03 29.16,83.03 26.87,80.74 26.87,75.3 30.45,71.72 30.45,60.33 28.29,58.17 27.33,58.17 v1(26.82,58.67) 26.31,58.17 24.15,58.17 24.04,58.27 C389.1
  IN1 w0.14: v2(147.43,106.45) 147.55,106.33 147.55,106.11 145.18,103.75 145.18,102.69 144.96,102.46 138.8,102.46 137.68,103.58 136.32,103.58 135.03,104.86 133.51,104.86 132.32,106.06 130.06,106.06 127.56,103.56 125.15,103.56 122.01,100.42 121.25,100.42 120.88,100.05 116.61,100.05 112.91,96.36 112.91,95.84 110.88,93.81 110.88,93.43 109.7,92.25 109.27,92.25 106.14,89.13 106.14,83.59 101.89,79.34 95.87,79.34 95.71,79.5 88.63,79.5 88.05,78.92 74.61,78.92 73.99,78.3 67.01,78.3 64.79,80.52 37.03,80.52 35.81,81.74 32.75,81.74 31.38,83.12 30.26,83.12 v2(30.01,83.36)
  BOTTOM w0.076: U25.B34 147.62,104.78 147.57,104.83 147.57,106.31 v2(147.43,106.45)
USB30_TX1+_C: length 12.3
  TOP w0.127: CN25.9 13.9,63.98 14.07,63.81 14.5,63.81 14.91,63.4 17.01,63.4 19.28,61.13 19.28,60.51 v1(19.8,59.99) 19.25,59.44 19.25,58.46 19.37,58.33 20.58,58.33 R305.1
USB30_TX1+_DC: length 14.8
  TOP w0.127: v2(66.97,162.75) 66.71,163.02 65.35,163.02 v1(64.82,162.48) 64.29,163.02 63.45,163.02 62.03,164.44 62.03,165.16 61.89,165.3 U8021.19
  BOTTOM w0.127: C8783.2 72.28,165.94 71.26,165.94 68.34,163.02 67.24,163.02 v2(66.97,162.75)
USB30_TX1+_L: length 6.6
  TOP w0.127: R8548.1 72.28,165.94 71.89,165.94 71.63,166.2 71.63,167.9 71.97,168.24 v1(71.97,168.99) 72.72,168.99 73.02,169.29 73.02,169.62 R8553.2
USB30_TX1-: length 175.5
  TOP w0.127: v2(30.01,82.6) 29.81,82.8 29.26,82.8 27.1,80.65 27.1,75.39 30.68,71.81 30.68,60.24 28.38,57.94 27.35,57.94 v1(26.82,57.4) 26.29,57.94 24.26,57.94 C391.1
  IN1 w0.14: v2(148.02,106.2) 145.45,103.64 145.45,102.58 145.07,102.2 138.69,102.2 137.57,103.31 136.2,103.31 134.92,104.6 133.4,104.6 132.21,105.79 130.17,105.79 127.67,103.29 125.26,103.29 122.12,100.15 121.36,100.15 120.99,99.78 116.72,99.78 113.18,96.24 113.18,95.73 111.15,93.7 111.15,93.32 109.82,91.99 109.38,91.99 106.41,89.02 106.41,83.48 102,79.07 95.76,79.07 95.59,79.24 88.74,79.24 88.16,78.66 74.72,78.66 74.1,78.03 66.9,78.03 64.68,80.25 36.92,80.25 35.7,81.47 32.64,81.47 31.27,82.85 30.26,82.85 v2(30.01,82.6)
  BOTTOM w0.076: v2(148.02,106.2) 147.74,105.92 147.74,104.9 148.04,104.59 148.04,104.35 U25.C33
USB30_TX1-_C: length 12.3
  TOP w0.127: R306.1 20.58,58.1 19.28,58.1 19.02,58.36 19.02,59.51 v1(18.53,59.99) 19.05,60.51 19.05,61.04 16.91,63.17 14.82,63.17 14.41,63.58 14.01,63.58 13.9,63.47 CN25.8
USB30_TX1-_DC: length 14.8
  TOP w0.127: v2(66.97,163.51) 66.97,163.39 66.83,163.25 65.33,163.25 v1(64.82,163.75) 64.31,163.25 63.55,163.25 62.26,164.54 62.26,165.16 62.39,165.3 U8021.20
  BOTTOM w0.127: C8785.2 72.76,166.26 72.67,166.17 71.17,166.17 68.25,163.25 67.11,163.25 66.97,163.38 v2(66.97,163.51)
USB30_TX1-_L: length 6.6
  TOP w0.127: R8552.2 73.42,170.15 73.25,169.98 73.25,169.2 72.87,168.82 v1(72.87,168.09) 72.14,168.09 71.86,167.81 71.86,166.29 71.99,166.17 72.67,166.17 72.76,166.26 R8549.1
USB30_TX2+: length 184.9
  TOP w0.127: C417.1 22.77,47.04 23.07,47.04 23.29,47.26 23.29,50.11 23.62,50.44 24,50.44 v1(24.53,50.98) 25.06,50.46 25.34,50.46 28.34,53.46 28.34,55.78 32.18,59.61 32.18,72.44 29.06,75.55 29.06,79.15 29.21,79.3 29.21,81.18 29.49,81.46 29.73,81.46 v2(30.02,81.75)
  IN1 w0.14: v2(148.67,106.3) 148.67,106.26 148.12,105.7 148.12,103.11 146.06,101.05 137.31,101.05 134.54,103.82 133.2,103.82 131.91,105.12 131.08,105.12 128.6,102.64 125.53,102.64 122.39,99.5 121.63,99.5 121.26,99.14 117.22,99.14 113.98,95.9 113.98,95.39 112.02,93.43 112.02,93.26 107.2,88.43 107.2,83.35 101.81,77.97 99.02,77.97 98.57,78.41 96.46,78.41 96.18,78.13 89.28,78.13 88.94,77.79 81.8,77.79 81.57,78.01 74.99,78.01 74.37,77.38 66.63,77.38 64.41,79.6 36.63,79.6 35.47,80.76 31.85,80.76 31.17,81.44 30.33,81.44 v2(30.02,81.75)
  BOTTOM w0.102: U25.A33 148.19,105.52 148.19,105.75 148.67,106.23 v2(148.67,106.3)
USB30_TX2+_C: length 7.5
  TOP w0.127: CN28.9 13.9,47.07 14.17,46.79 14.68,46.79 15.08,46.39 16.41,46.39 v1(16.93,46.91) 16.93,46.51 17.05,46.38 17.56,46.38 17.63,46.45 17.63,46.79 17.87,47.03 18.39,47.03 18.76,47.4 R322.1
USB30_TX2-: length 184.8
  TOP w0.127: v2(30.02,80.99) 29.77,81.24 29.59,81.24 29.44,81.08 29.44,79.2 29.29,79.06 29.29,75.65 32.41,72.53 32.41,59.52 28.57,55.69 28.57,53.37 25.44,50.23 25.06,50.23 v1(24.53,49.71) 24.03,50.22 23.71,50.22 23.52,50.02 23.52,47.17 23.16,46.81 22.63,46.81 22.38,46.57 C420.1
  IN1 w0.14: v2(148.68,105.66) 148.39,105.37 148.39,103 146.17,100.79 137.19,100.79 134.42,103.56 133.09,103.56 131.8,104.85 131.19,104.85 128.71,102.37 125.64,102.37 122.5,99.24 121.74,99.24 121.37,98.87 117.33,98.87 114.25,95.79 114.25,95.28 112.29,93.32 112.29,93.15 107.47,88.32 107.47,83.24 101.92,77.7 98.91,77.7 98.46,78.14 96.57,78.14 96.29,77.86 89.39,77.86 89.05,77.52 81.68,77.52 81.46,77.74 75.1,77.74 74.48,77.12 66.52,77.12 64.3,79.34 36.51,79.34 35.36,80.5 31.74,80.5 31.06,81.17 30.2,81.17 v2(30.02,80.99)
  BOTTOM w0.076: v2(148.68,105.66) 148.56,105.54 148.56,105.36 148.19,104.98 U25.B33
USB30_TX2-_C: length 7.5
  TOP w0.127: CN28.8 13.9,46.29 14.18,46.57 14.59,46.57 14.99,46.17 16.41,46.17 v1(16.93,45.64) 16.93,46.05 17.03,46.15 17.65,46.15 17.85,46.36 17.85,46.69 17.96,46.8 18.29,46.8 18.83,46.25 R324.1
USB30_TX3+: length 130.6
  TOP w0.127: C486.1 195.54,33.77 195.43,33.88 195.43,34.09 195.95,34.62 196.22,34.62 v2(196.49,34.35)
  IN1 w0.14: v2(149.2,107.67) 149.2,107.67 149.56,107.67 149.67,107.79 152.41,107.79 152.88,107.32 154.19,107.32 154.66,107.79 157.72,107.79 158.05,108.12 161.06,108.12 161.39,107.79 170.09,107.79 171.22,106.66 176.63,106.66 178.72,108.75 185.78,108.75 186.83,107.7 190.93,107.7 191.17,107.45 192.97,107.45 197.51,102.92 197.51,97.97 198.47,97 198.47,82.18 198.07,81.78 198.07,76.36 197.71,76 197.71,73 199.65,71.06 199.65,65.04 200.16,64.53 200.16,58.69 200.01,58.53 200.01,57.56 200.01,37.56 197.02,34.57 196.7,34.57 v2(196.49,34.35)
  BOTTOM w0.076: U25.C31 149.29,104.48 149.23,104.51 149.16,104.66 149.08,104.8 149.12,105 149.18,105.15 149.17,105.28 149.08,105.46 149.08,105.53 149.08,105.66 149.08,106.67 149.06,106.73
  BOTTOM w0.127: v2(149.2,107.67) 149.16,107.64 149.16,107.3 149.06,107.19 149.06,106.73
USB30_TX3+_C: length 8
  TOP w0.127: C486.2 195.54,32.99 195.38,32.82 195.38,32.45 v1(195.92,31.9) 195.4,31.38 195.4,31.16 195.1,30.86 192.53,30.86 191.69,31.7 191.51,31.7 191.27,31.46 U15.19
USB30_TX3+_DC: length 8.5
  TOP w0.127: C514.2 195.13,25.17 195.37,25.17 195.57,25.37 195.98,25.37 196.24,25.63 v1(196.24,25.88) 196.76,25.36 196.99,25.36 197.1,25.47 197.1,28.32 197.9,29.11 198.21,29.11 198.35,29.25 CN14.29
USB30_TX3+_DC_L: length 5.1
  TOP w0.127: C514.1 193.54,25.17 193.29,25.17 v1(192.81,25.65) 192.81,25.2 192.66,25.04 192.27,25.04 191.63,25.68 191.38,25.68 191.13,25.93 191.13,26.2 191.27,26.33 U15.12
USB30_TX3-: length 130.6
  TOP w0.127: v2(196.49,35.12) 196.22,34.85 195.86,34.85 195.2,34.19 195.2,34.02 194.94,33.77 C485.1
  IN1 w0.14: v3(149.67,107.23) 149.67,107.4 149.78,107.52 152.3,107.52 152.77,107.05 154.3,107.05 154.77,107.52 157.83,107.52 158.16,107.85 160.95,107.85 161.28,107.52 169.98,107.52 171.11,106.4 176.75,106.4 178.83,108.48 185.67,108.48 186.72,107.43 190.82,107.43 191.06,107.19 192.86,107.19 197.24,102.81 197.24,97.85 198.21,96.89 198.21,82.31 197.81,81.91 197.81,76.47 197.44,76.11 197.44,73.11 197.45,73.11 197.45,72.89 199.39,70.95 199.39,65.1 199.39,64.92 199.89,64.42 199.89,58.8 199.74,58.65 199.74,58.42 199.74,37.67 196.91,34.84 196.77,34.84 v2(196.49,35.12)
  BOTTOM w0.076: 149.29,106.73 149.29,106.71 149.25,106.67 149.25,105.66 149.25,105.53 149.25,105.5 149.33,105.32 149.35,105.13 149.28,104.96 149.26,104.83 149.35,104.64 149.5,104.57 149.68,104.57 149.78,104.5 149.95,104.2 150.2,104.2 150.32,104.09 150.32,103.96 150.24,103.89 U25.C30
  BOTTOM w0.127: v3(149.67,107.23) 149.41,107.23 149.29,107.1 149.29,106.73
USB30_TX3-_C: length 8
  TOP w0.127: C485.2 194.98,32.99 195.15,32.82 195.15,32.4 v1(194.65,31.9) 195.17,31.38 195.17,31.25 195.01,31.09 192.62,31.09 191.79,31.93 191.41,31.93 190.77,31.28 U15.20
USB30_TX3-_DC: length 8.5
  TOP w0.127: CN14.28 198.35,28.75 198.21,28.89 197.99,28.89 197.33,28.23 197.33,25.37 197.09,25.13 196.76,25.13 v1(196.24,24.61) 196.24,24.89 195.98,25.15 195.67,25.15 195.46,24.94 195.1,24.94 C520.2
USB30_TX3-_DC_L: length 5.1
  TOP w0.127: C520.1 193.56,24.94 193.37,24.94 v1(192.81,24.38) 192.38,24.82 192.17,24.82 191.54,25.45 191.29,25.45 190.9,25.84 190.9,26.2 190.77,26.33 U15.11
USB30_TX4+: length 110.7
  TOP w0.127: R8548.2 73.43,165.57 73.43,165.99 73.62,166.18 74.12,166.18 74.34,165.96 74.34,165.96 74.52,165.78 v2(74.52,165.65) 74.79,165.91 75.87,165.91 78.87,162.92 82.79,162.92 83.85,162.92 104.89,141.87 104.89,141.83 113.09,133.63 130,133.63 139.16,124.47 139.48,124.47 v2(139.75,124.21)
  BOTTOM w0.127: v2(74.52,165.65) 74.23,165.94 74.02,165.94 C8783.1 ; U25.A31 149.65,105.6 149.65,105.72 149.45,105.92 149.45,106.1 149.65,106.3 149.65,106.58 150.09,107.01 150.09,107.5 148.61,108.97 148.61,109.86 148.35,110.11 148.35,111.44 v1(147.78,112.02) 148.26,112.49 148.26,112.65 145.44,115.47 145.44,119.79 140.81,124.42 139.96,124.42 v2(139.75,124.21)
USB30_TX4-: length 110.7
  TOP w0.127: R8549.2 73.78,166.41 v2(74.52,166.41) 74.79,166.14 75.97,166.14 78.97,163.14 82.69,163.14 83.94,163.14 105.12,141.97 105.12,141.93 113.19,133.86 130.1,133.86 139.26,124.7 139.48,124.7 v2(139.75,124.97)
  BOTTOM w0.127: v2(74.52,166.41) 74.28,166.17 74.02,166.17 C8785.1 ; U25.B31 149.88,105.18 149.88,106.48 150.32,106.92 150.32,107.59 148.84,109.07 148.84,109.95 148.58,110.21 148.58,111.55 v1(149.05,112.02) 148.51,112.55 148.51,112.72 145.67,115.57 145.67,119.89 140.9,124.65 140.07,124.65 v2(139.75,124.97)
USB_BIAS: length 3.5
  TOP w0.127: v1(162.02,87.88) 162.08,87.88 162.6,88.41 v2(162.65,88.41) 162.65,88.51 R193.1
  BOTTOM w0.127: v2(162.65,88.41) 162.65,89 U25.AJ10 U25.AJ11
USB_OC1#: length 13.9
  TOP w0.127: v3(168.48,88.65) 168.48,88.47 168.05,88.04 168.05,87.5 168.27,87.27 170.66,87.27 171.81,88.42 174.93,88.42 175.71,89.21 176.05,89.21 176.55,88.7 177.18,88.7 R195.1
  BOTTOM w0.076: U25.AL3 166.82,88.3 166.83,88.3 166.87,88.26 168.04,88.26 168.25,88.47 168.3,88.47 v3(168.48,88.65)
USB_OC2#: length 15.5
  TOP w0.127: v2(168.5,85.45) 168.58,85.37 v1(169.29,85.37) 169.84,85.37 172.13,87.66 176.68,87.66 176.83,87.81 177.39,87.81 178.4,86.8 178.4,86.42 178.73,86.09 180.82,86.09 R211.1
  BOTTOM w0.127: v2(168.5,85.45) 168.46,85.49 167.94,85.49 U25.AT1
USB_OC3#: length 13.1
  BOTTOM w0.076: U25.AH2 167.26,90.08 167.69,90.51 168.1,90.51 168.24,90.37 168.78,90.37 169.29,90.88
  BOTTOM w0.127: 169.29,90.88 170.03,90.88 170.46,91.31 170.97,91.31 v1(171.22,91.57) 171.32,91.47 174.13,91.47 174.73,92.07 176.8,92.07 177.06,92.32 177.88,92.32 178.46,91.75 R561.1
USB_OC4#: length 20.6
  BOTTOM w0.076: 167.21,82.49 166.98,82.72 166.98,83.02 166.92,83.08 166.92,83.72 166.59,84.05 U25.AV3
  BOTTOM w0.127: 167.21,82.49 167.61,82.09 168.84,82.09 171.17,84.43 171.17,84.51 v1(171.98,85.32) 172.24,85.58 176.41,85.58 176.54,85.45 177.03,85.45 178.57,83.9 178.57,83.66 178.94,83.29 180.52,83.29 181.18,83.95 181.18,85.34 R571.1
USBP0+: length 271.8
  TOP w0.127: U10.3 21.09,73.97 20.93,74.13 20.57,74.13 v2(20.31,73.88)
  IN1 w0.076: 163.33,87.97 v2(163.22,88.09) ; 163.77,87.97 163.97,87.77 163.97,85.86 164.91,84.92 164.91,84.45 164.99,84.37 165.04,84.31 165.1,84.31 165.11,84.3
  IN1 w0.14: 163.77,87.97 163.33,87.97 ; v2(24.28,81.33) 24.28,80.37 24.72,79.93 25.17,79.93 27.7,77.41 27.7,76.52 30.65,73.57 35.31,73.57 36.08,74.33 44.58,74.33 45.07,74.82 50.08,74.82 50.69,74.21 53.38,74.21 55.06,72.53 59.37,72.53 63.26,68.64 63.26,64.58 64.35,63.49 65.75,63.49 69.87,59.36 69.87,58.04 74.05,53.86 74.05,51.22 79.89,45.38 79.89,40.42 82.45,37.87 82.45,36.12 86.92,31.65 86.92,30.56 87.85,29.63 89.67,29.63 90.44,30.4 106.94,30.4 110.81,26.53 111.97,26.53 112.56,25.95 167.85,25.95 168.85,26.94 173.35,26.94 174.48,28.07 174.48,28.72 175.33,29.57 175.33,32.59 176.84,34.1 176.84,42.63 176.41,43.07 176.41,45.46 175.85,46.02 175.85,59.52 176.44,60.11 176.44,62.37 175.44,63.37 175.44,65.5 174.51,66.43 174.51,70.54 171.94,73.11 171.94,74.36 171.45,74.85 171.17,74.85 170.93,75.1 170.93,75.53 165.82,80.63 165.82,83.58 165.11,84.3
  BOTTOM w0.076: U25.AM8 163.29,88.09 v2(163.22,88.09)
  BOTTOM w0.127: R594.2 22.34,75.9 22.04,75.9 21.96,75.81 21.96,74.64 21.46,74.14 20.58,74.14 v2(20.31,73.88) 20.17,74.02 19.36,74.02 18.92,74.45 18.92,77.82 21.9,80.8 24.1,80.8 24.28,80.98 v2(24.28,81.33)
USBP0+_C: length 11.3
  TOP w0.127: R310.1 20.86,55.66 20.06,55.66 19.77,55.94 19.09,55.94 v1(18.57,55.42) 18.04,55.94 17.68,55.94 17.45,56.17 17.45,60.25 17.11,60.59 15.53,60.59 15.4,60.46 CN25.3
USBP0+_CHA: length 31.7
  TOP w0.127: U10.10 25.4,73.97 25.54,74.1 25.66,74.1 v2(25.93,73.84) ; v2(23.14,55.68) 22.86,55.96 22.68,55.96 22.38,55.66 21.86,55.66 R310.2
  IN1 w0.14: v2(25.93,73.84) 25.71,74.06 25.5,74.06 25.35,73.91 25.35,73.41 25.55,73.2 25.55,71.77 25.8,71.51 26.58,71.51 30.11,67.98 30.11,63.87 25.61,59.37 24.9,59.37 24.13,58.6 24.13,56.39 23.68,55.94 23.4,55.94 v2(23.14,55.68)
  BOTTOM w0.127: R594.1 23.53,75.78 23.65,75.9 23.93,75.9 24.61,75.22 24.61,74.7 25.25,74.07 25.7,74.07 v2(25.93,73.84)
USBP0-: length 271.8
  TOP w0.127: U10.2 21.11,74.47 21,74.36 20.59,74.36 v2(20.31,74.64)
  IN1 w0.076: 164.92,84.11 164.91,84.12 164.91,84.16 ; 164.7,84.36 164.7,84.83 163.76,85.77 163.76,87.69 163.68,87.77 163.51,87.77 v2(163.19,87.45)
  IN1 w0.14: 164.92,84.11 165.56,83.47 165.56,80.52 170.66,75.42 170.66,74.98 171.06,74.59 171.34,74.59 171.68,74.25 171.68,73 174.24,70.43 174.24,66.32 175.18,65.39 175.18,63.26 176.17,62.26 176.17,60.22 175.58,59.63 175.58,45.91 176.14,45.35 176.14,42.96 176.57,42.52 176.57,34.21 175.07,32.7 175.07,29.68 174.22,28.83 174.22,28.19 173.24,27.21 168.74,27.21 167.74,26.21 112.67,26.21 112.08,26.8 110.92,26.8 107.05,30.67 90.33,30.67 89.56,29.9 87.96,29.9 87.18,30.67 87.18,31.76 82.71,36.23 82.71,37.98 80.16,40.53 80.16,45.49 74.32,51.33 74.32,53.97 70.14,58.15 70.14,59.47 65.86,63.76 64.46,63.76 63.52,64.69 63.52,68.75 59.48,72.8 55.17,72.8 53.49,74.47 50.8,74.47 50.19,75.08 44.96,75.08 44.47,74.6 35.96,74.6 35.2,73.84 30.76,73.84 27.96,76.63 27.96,77.52 25.28,80.2 24.83,80.2 24.55,80.48 24.55,80.94 24.94,81.33 v2(25.04,81.33) ; 164.91,84.16 164.7,84.36
  BOTTOM w0.076: v2(163.19,87.45) 163.75,87.45 163.85,87.35 163.85,87.17 163.79,87.11 U25.AN8
  BOTTOM w0.127: R587.2 22.37,76.12 21.94,76.12 21.73,75.91 21.73,74.73 21.37,74.37 20.58,74.37 v2(20.31,74.64) 20.31,74.52 20.04,74.24 19.45,74.24 19.15,74.55 19.15,77.72 21.99,80.57 24.2,80.57 24.45,80.82 24.92,80.82 25.04,80.95 v2(25.04,81.33)
USBP0-_C: length 11.3
  TOP w0.127: CN25.2 15.4,60.94 15.53,60.81 17.21,60.81 17.68,60.34 17.68,56.27 17.77,56.17 18.04,56.17 v1(18.57,56.69) 19.09,56.17 19.82,56.17 20.11,56.46 20.86,56.46 R307.1
USBP0-_CHA: length 31.7
  TOP w0.127: U10.11 25.4,74.47 25.53,74.33 25.66,74.33 v2(25.93,74.6) ; v2(23.11,56.44) 22.86,56.19 22.71,56.19 22.43,56.46 21.86,56.46 R307.2
  IN1 w0.14: v2(23.11,56.44) 23.34,56.21 23.57,56.21 23.86,56.5 23.86,58.71 24.79,59.64 25.5,59.64 29.84,63.98 29.84,67.87 26.47,71.25 25.69,71.25 25.28,71.66 25.28,73.09 25.08,73.3 25.08,74.02 25.39,74.33 25.73,74.33 25.93,74.52 v2(25.93,74.6)
  BOTTOM w0.127: R587.1 23.53,76.24 23.65,76.12 24.03,76.12 24.84,75.31 24.84,74.8 25.34,74.3 25.63,74.3 v2(25.93,74.6)
USBP1+: length 80.4
  TOP w0.127: L29.4 197.11,34.04 197.39,34.33 197.39,35.06 198.99,36.65 200.99,36.65 201.22,36.88 201.22,44.15 200.07,45.3 200.07,47.51 195.46,52.12 191.82,52.12 191.72,52.02 182.52,52.02 176.88,57.66 176.88,58.01 176.57,58.32 v2(176.51,58.32)
  IN1 w0.076: 167.08,80.65 167.08,80.73 167.08,80.73 166.08,81.73 166.08,85.33 165.61,85.8 165.24,85.8 164.96,86.08 164.94,86.1 164.78,86.1 164.58,85.9 v2(164.58,85.8)
  IN1 w0.14: 167.08,80.65 169.07,78.66 169.07,78.12 170.6,76.59 171.29,76.59 171.92,75.96 171.92,75.12 172.46,74.57 172.46,73.51 176.01,69.97 176.01,66.41 176.55,65.87 176.55,63 176.96,62.59 176.96,59.06 176.81,58.9 176.81,58.62 v2(176.51,58.32)
  BOTTOM w0.076: v2(164.58,85.8) 164.33,85.8 164.17,85.64 U25.AT7
USBP1+_C: length 9.8
  TOP w0.127: CN14.23 199.88,26.25 200.02,26.11 200.38,26.11 200.63,26.37 200.63,29.42 199.78,30.28 198.02,30.28 197.68,30.62 197.68,31.07 197.56,31.19 197.23,31.19 197.11,31.31 L29.3
USBP1-: length 80.4
  TOP w0.127: L29.1 197.91,34.07 197.62,34.35 197.62,34.96 199.08,36.42 201.08,36.42 201.45,36.79 201.45,44.25 200.3,45.39 200.3,47.61 195.56,52.35 191.72,52.35 191.62,52.25 182.62,52.25 177.11,57.75 177.11,58.17 v2(177.27,58.32)
  IN1 w0.076: v3(164.58,86.46) 164.77,86.27 165.01,86.27 165.31,85.96 165.68,85.96 166.24,85.4 166.24,81.8 167.21,80.84 167.27,80.84 167.28,80.82
  IN1 w0.14: 167.28,80.82 167.31,80.82 169.34,78.79 169.34,78.23 170.71,76.86 171.4,76.86 172.18,76.07 172.18,75.23 172.73,74.69 172.73,73.62 176.27,70.08 176.27,66.52 176.82,65.98 176.82,63.11 177.23,62.7 177.23,58.94 177.07,58.79 177.07,58.52 v2(177.27,58.32)
  BOTTOM w0.076: U25.AR7 164.26,86.14 v3(164.58,86.46)
USBP1-_C: length 9.8
  TOP w0.127: CN14.22 199.92,25.75 200.05,25.89 200.48,25.89 200.86,26.27 200.86,29.52 199.87,30.51 198.12,30.51 197.91,30.72 L29.2
USBP3+: length 54.6
  TOP w0.127: L22.4 192.97,53.45 192.68,53.73 192.39,53.73 191.41,52.76 182.97,52.76 179.55,56.17 179.55,56.84 v1(179.03,57.36) 179.55,57.88 179.55,58.42 177.65,60.33 176.38,61.59 176.03,61.59 175.63,61.19 v2(175.63,60.99)
  IN1 w0.14: v2(175.63,60.99) 175.36,61.26 174.66,61.26 174.03,61.89 174.03,63.48 173.44,64.06 173.44,70.12 163.68,79.89 163.68,82.78 163.09,83.36 163.09,84.68 162.67,85.11 v2(162.67,85.14)
  BOTTOM w0.127: v2(162.67,85.14) 162.32,85.49 U25.AT10
USBP3+_C: length 5.7
  TOP w0.127: L22.3 195.73,53.45 196.02,53.73 196.19,53.73 v1(196.75,53.18) 196.75,53.52 196.92,53.7 197.31,53.7 197.86,54.25 197.86,54.93 198.06,55.14 198.15,55.14 198.44,54.85 CN11.6
USBP3-: length 54.5
  TOP w0.127: v2(175.63,61.82) 176.47,61.82 179.78,58.51 179.78,57.88 v1(180.3,57.36) 179.78,56.84 179.78,56.27 183.06,52.98 191.32,52.98 192.3,53.96 192.62,53.96 192.9,54.25 L22.1
  IN1 w0.14: v2(175.63,61.82) 175.33,61.52 174.77,61.52 174.29,62 174.29,63.59 173.71,64.17 173.71,70.23 163.94,80 163.94,82.89 163.36,83.47 163.36,84.79 163.09,85.06 163.09,85.36 v2(162.68,85.77)
  BOTTOM w0.127: U25.AR10 162.32,86.14 v2(162.68,85.77)
USBP3-_C: length 5.7
  TOP w0.127: L22.2 195.73,54.25 196.02,53.96 196.26,53.96 v1(196.75,54.45) 196.75,54.05 196.87,53.92 197.21,53.92 197.63,54.34 197.63,55.03 197.96,55.36 198.16,55.36 198.45,55.65 CN11.7
USBP4+: length 252.3
  TOP w0.127: v2(159.13,88.54) 158.83,88.24 158.45,88.24 158.11,87.9 158.11,85.86 158.98,84.99 159.82,84.99 160.09,84.72 160.09,79.98 159.54,79.43 159.54,77.78 158.16,76.4 158.16,75.83 159.66,74.33 159.66,61.6 169.39,51.87 169.39,35.56 167.97,34.14 167.87,34.14 166.75,33.02 166.75,31.27 166.5,31.02 166.5,26.08 164.4,23.98 154.4,23.98 151.97,21.55 151.97,20.81 149.57,18.42 127.08,18.42 123.13,14.47 117.79,14.47 115.35,14.47 115.05,14.76 113.52,14.76 113.31,14.55 113,14.55 v2(112.55,14.1) ; v2(38.66,50.74) 38.4,51 38.02,51 37.29,51.74 36.73,51.74 36.49,51.98 36.49,52.36 36.2,52.65 36.2,53.2 R317.2
  IN1 w0.14: v2(38.66,50.74) 38.78,50.85 44.86,50.85 46.49,49.22 46.49,46.52 45.73,45.75 45.73,43.85 40.77,38.89 40.77,22.68 42.73,20.72 63.2,20.72 70.93,12.99 81.54,12.99 82.35,13.8 84.07,13.8 86.15,11.72 88.93,11.72 89.31,12.1 95.21,12.1 95.69,11.62 108.67,11.62 111.69,14.64 112.44,14.64 112.67,14.41 112.67,14.22 v2(112.55,14.1)
  BOTTOM w0.127: v2(159.13,88.54) 159.26,88.41 U25.AL15
USBP4+_C: length 7.7
  TOP w0.127: CN12.5 38.96,57.5 38.84,57.38 38.58,57.38 38.3,57.66 36.94,57.66 36.45,57.17 36.45,56.48 C397.1 36.3,55.97 36.47,55.8 36.47,54.62 R317.1
USBP4-: length 252.4
  TOP w0.127: v2(113.18,14.1) 113.61,14.53 114.96,14.53 115.25,14.24 117.7,14.24 123.23,14.24 127.18,18.19 149.67,18.19 152.2,20.71 152.2,21.45 154.49,23.75 164.5,23.75 166.73,25.98 166.73,30.92 166.98,31.17 166.98,32.93 167.96,33.91 168.06,33.91 169.62,35.47 169.62,51.97 159.89,61.7 159.89,74.42 158.39,75.92 158.39,76.31 159.76,77.68 159.76,79.33 160.32,79.89 160.32,84.81 159.92,85.22 159.08,85.22 158.34,85.95 158.34,87.81 158.54,88.01 159.04,88.01 v2(159.15,87.9) ; R316.2 37,53.22 37,52.65 36.71,52.36 36.71,52.08 36.82,51.97 37.38,51.97 38.12,51.23 38.4,51.23 v2(38.66,51.5)
  IN1 w0.14: v2(113.18,14.1) 112.94,14.34 112.94,14.52 112.55,14.9 111.58,14.9 108.56,11.89 95.81,11.89 95.32,12.37 89.2,12.37 88.82,11.99 86.26,11.99 84.18,14.07 82.24,14.07 81.43,13.26 71.04,13.26 63.31,20.99 42.84,20.99 41.04,22.79 41.04,38.78 46,43.74 46,45.64 46.76,46.41 46.76,49.33 44.97,51.12 39.04,51.12 v2(38.66,51.5)
  BOTTOM w0.127: v2(159.15,87.9) 159.33,88.09 159.87,88.09 159.97,87.99 159.97,87.86 159.87,87.76 U25.AM15
USBP4-_C: length 7.7
  TOP w0.127: CN12.4 39.1,56.5 38.94,56.67 38.94,57 38.78,57.15 38.49,57.15 38.21,57.43 37.03,57.43 36.68,57.07 36.68,56.51 C396.1 36.87,55.97 36.7,55.8 36.7,54.62 R316.1
USBP5+: length 234.5
  TOP w0.127: v2(22.25,43.74) 21.94,44.04 21.31,44.04 20.98,43.72 L27.1
  IN1 w0.076: v2(160.75,87.14) 160.75,87.17 161.15,87.57 161.34,87.57 161.7,87.21 161.7,85.14 161.66,85.1 161.66,85.01
  IN1 w0.14: 161.66,85.01 161.66,83.88 162.99,82.55 162.99,79.46 172.64,69.81 172.64,63.75 173.24,63.15 173.24,60.19 174.79,58.63 174.79,45.58 175.35,45.02 175.35,42.53 175.79,42.1 175.79,35.05 174.28,33.54 174.28,30.26 173.05,29.03 173.05,28.17 172.88,28 168.41,28 167.43,27.02 113.06,27.02 112.44,27.64 111.35,27.64 107.43,31.56 96.78,31.56 96.29,32.06 88.8,32.06 88.28,31.53 88.28,31.15 v2(88.03,30.91)
  BOTTOM w0.076: v2(160.75,87.14) 160.46,87.14 160.34,87.26 U25.AN13
  BOTTOM w0.127: v2(22.25,43.74) 22.25,43.86 22.66,44.27 22.99,44.27 23.93,43.33 23.93,39.71 27.16,36.47 29.15,36.47 32.31,33.31 37.64,33.31 37.85,33.52 40.56,33.52 41.25,34.2 69.05,34.2 72.43,30.82 85.98,30.82 86.96,31.8 88.09,31.8 88.39,31.5 88.39,31.27 v2(88.03,30.91)
USBP5+_C: length 4.9
  TOP w0.127: L27.2 18.46,43.72 18.17,44.01 18.01,44.01 17.64,43.64 17.27,43.64 17.09,43.46 v1(17.09,43.09) 16.6,43.59 15.76,43.59 15.4,43.22 15.4,42.7 CN28.3
USBP5-: length 234.4
  TOP w0.127: v2(22.25,44.5) 22.02,44.27 21.37,44.27 21.13,44.52 L27.4
  IN1 w0.076: 161.93,85.01 161.93,85.11 161.9,85.14 161.9,87.3 161.43,87.77 v2(160.77,87.77)
  IN1 w0.14: v2(88.8,30.91) 88.54,31.17 88.54,31.42 88.91,31.79 96.18,31.79 96.67,31.29 107.32,31.29 111.24,27.37 112.33,27.37 112.94,26.76 167.54,26.76 168.52,27.73 172.99,27.73 173.32,28.06 173.32,28.92 174.55,30.15 174.55,33.43 176.05,34.94 176.05,42.21 175.62,42.64 175.62,45.13 175.06,45.69 175.06,58.74 173.51,60.3 173.51,63.26 172.91,63.86 172.91,69.92 163.26,79.57 163.26,82.66 161.93,83.99 161.93,85.01
  BOTTOM w0.076: v2(160.77,87.77) 160.65,87.77 U25.AM13
  BOTTOM w0.127: v2(88.8,30.91) 88.62,31.09 88.62,31.6 88.19,32.03 86.87,32.03 85.89,31.05 72.53,31.05 69.15,34.43 41.15,34.43 40.47,33.75 37.76,33.75 37.55,33.54 32.41,33.54 29.24,36.7 27.25,36.7 24.15,39.8 24.15,43.43 23.08,44.5 v2(22.25,44.5)
USBP5-_C: length 4.9
  TOP w0.127: L27.3 18.46,44.52 18.17,44.23 17.92,44.23 17.55,43.87 17.3,43.87 17.09,44.07 v1(17.09,44.36) 16.55,43.82 15.8,43.82 15.4,44.21 CN28.2
USBP6+: length 113.8
  TOP w0.127: v2(188.75,108.85) 189.03,108.58 189.03,107.85 189.15,107.72 189.15,106.84 190.02,105.98 190.02,96.88 188.76,95.62 188.76,94.6 186.5,92.34 185.36,92.34 182.62,89.6 182.62,84.72 181.59,83.68 179.76,83.68 176.55,86.9 172.45,86.9 170.53,84.99 170.53,84.6 169.97,84.04 162.48,84.04 162.22,84.3 162.22,86.27 161.9,86.59 161.5,86.59 v2(161.29,86.8)
  IN1 w0.14: v2(188.75,108.85) 188.96,109.07 189.08,109.07 189.53,109.53 194.14,109.53 196.87,112.25 196.87,131.34 192.85,135.37 192.85,153.76 191.56,155.05 191.37,155.05 191.18,154.86 v2(191.18,154.74)
  BOTTOM w0.076: 161.31,86.82 v2(161.29,86.8)
  BOTTOM w0.127: U25.AN11 161.61,87.11 161.31,86.82 ; v2(191.18,154.74) 191.18,154.89 191.33,155.04 191.59,155.04 191.9,155.35 191.9,155.8 192.2,156.11 CN22.38
USBP6-: length 113.6
  TOP w0.127: v2(189.51,108.85) 189.25,108.6 189.25,107.94 189.38,107.82 189.38,107.21 189.38,107.21 189.38,107.02 189.38,107.02 189.38,106.93 189.44,106.87 190.24,106.07 190.24,96.79 188.99,95.53 188.99,94.51 186.59,92.11 185.45,92.11 184.86,91.52 182.85,89.5 182.85,84.62 181.68,83.46 179.67,83.46 176.45,86.67 172.54,86.67 170.76,84.89 170.76,84.51 170.07,83.81 162.39,83.81 161.99,84.2 161.99,86.17 161.8,86.36 161.52,86.36 v3(161.3,86.14)
  IN1 w0.14: v2(191.18,155.5) 191.36,155.32 191.67,155.32 193.11,153.87 193.11,135.48 197.14,131.45 197.14,112.14 194.26,109.26 189.64,109.26 189.51,109.12 v2(189.51,108.85)
  BOTTOM w0.076: 161.31,86.15 v3(161.3,86.14)
  BOTTOM w0.127: U25.AP11 161.62,86.46 161.31,86.15 ; v2(191.18,155.5) 191.41,155.27 191.5,155.27 191.67,155.44 191.67,155.83 191.4,156.1 CN22.36
USBP7+: length 285.4
  TOP w0.127: v2(65.95,170.42) 66.19,170.66 66.19,171.34 66.27,171.42 66.27,172.06 v1(66.21,172.12) 66.22,172.13 66.89,172.13 66.98,172.21 66.98,172.32 66.68,172.62 L7.3
  IN1 w0.076: 159.43,90.56 159.43,90.49 159.85,90.08 159.85,89.35 160.23,88.96 160.23,86.3 160.29,86.25 160.53,86.25 v2(160.75,86.46)
  IN1 w0.14: 159.43,90.56 158.88,91.11 157.5,91.11 156.36,92.25 152.55,92.25 151.64,91.34 143.28,91.34 142.24,92.38 139.09,92.38 138.68,92.79 129.54,92.79 129.26,93.07 125.19,93.07 124.46,92.33 123.51,92.33 122.74,92.33 121.13,90.73 120.67,90.73 120.67,90.73 119.91,90.73 119.91,90.73 118.78,90.73 114.06,86.01 114.06,80.3 105.57,71.82 105.57,62.57 100.11,57.11 72.91,57.11 71.03,58.99 71.03,59.7 65.18,65.55 65.18,67.33 64.92,67.59 64.37,67.59 v2(64.18,67.78)
  BOTTOM w0.076: v2(160.75,86.46) 160.66,86.46 U25.AP13
  BOTTOM w0.127: v2(65.95,170.42) 66.22,170.69 66.22,170.94 66.44,171.17 67.16,171.17 67.66,170.66 67.66,169.22 64.42,165.98 37.1,165.98 33.35,162.23 33.35,113.07 44.22,102.2 44.22,97.76 48.49,93.5 48.49,87.83 51.18,85.14 51.18,83.79 55.46,79.51 56.32,79.51 57.35,78.48 57.35,74.97 61.13,71.19 61.13,71 61.13,70.19 63.7,67.62 64.02,67.62 v2(64.18,67.78)
USBP7+_C: length 3.3
  TOP w0.127: CN2.14 66.35,177.34 66.52,177.17 66.52,176.23 66.95,175.79 66.95,175.64 66.68,175.37 L7.4
USBP7-: length 285.4
  TOP w0.127: L7.2 67.48,172.62 67.28,172.42 67.28,172.42 67.21,172.34 67.21,172.11 67.11,172.01 v1(67.11,171.22) 66.94,171.39 66.56,171.39 66.42,171.25 66.42,170.71 v2(66.71,170.42)
  IN1 w0.076: v2(160.75,85.79) 160.46,86.08 160.22,86.08 160.07,86.23 160.07,88.89 159.69,89.28 159.69,90.01 159.32,90.38 159.29,90.4 159.21,90.4 159.2,90.41
  IN1 w0.14: v2(64.18,67.02) 64.18,67.15 64.36,67.33 64.81,67.33 64.91,67.22 64.91,65.44 70.76,59.59 70.76,58.88 72.8,56.84 100.22,56.84 105.84,62.46 105.84,71.7 114.32,80.19 114.32,85.9 118.89,90.46 120.02,90.46 121.24,90.46 122.85,92.07 122.87,92.07 124.57,92.07 125.3,92.8 129.15,92.8 129.43,92.52 138.57,92.52 138.98,92.11 142.13,92.11 143.17,91.07 151.75,91.07 152.66,91.99 156.25,91.99 157.39,90.84 158.77,90.84 159.16,90.45 159.2,90.41
  BOTTOM w0.076: U25.AR13 160.52,86.14 160.75,85.91 v2(160.75,85.79)
  BOTTOM w0.127: v2(66.71,170.42) 66.44,170.69 66.44,170.85 66.54,170.94 67.06,170.94 67.44,170.57 67.44,169.32 64.32,166.21 37,166.21 33.12,162.32 33.12,112.98 43.99,102.11 43.99,97.67 48.26,93.4 48.26,87.74 50.95,85.05 50.95,83.7 55.36,79.29 56.22,79.29 57.12,78.39 57.12,74.88 60.9,71.1 60.9,70.09 63.6,67.39 63.81,67.39 v2(64.18,67.02)
USBP7-_C: length 3.3
  TOP w0.127: CN2.13 66.85,177.27 66.75,177.17 66.75,176.32 67.18,175.89 67.18,175.67 67.48,175.37 L7.1
USBPW_ON#: length 267.6
  TOP w0.127: v2(42.09,76.48) 42.04,76.48 39.6,78.92 U11.125 ; CN14.9 198.38,19.25 197.25,20.37 EC55.1 196.81,20.93 196.81,21.58 195.81,22.58 189.84,22.58 189.53,22.89 v2(189.33,22.89)
  IN1 w0.14: v2(33.81,64.03) 33.81,63.66 26.95,56.81 26.95,53.84 21.9,48.79 21.9,48.47 v2(21.87,48.44) 20.45,47.02 20.45,45.1 20.09,44.75 20.09,42.2 25.09,37.2 25.09,32.31 33.73,23.67 33.73,18.31 35.3,16.74 43.21,16.74 44.86,15.1 56.09,15.1 56.84,15.85 67.28,15.85 70.88,12.26 81.83,12.26 82.85,13.28 83.85,13.28 v2(84.3,12.83)
  BOTTOM w0.127: v2(84.3,12.83) 86.08,14.61 87.43,14.61 90.47,11.56 94.1,11.56 95.11,10.55 108.38,10.55 108.62,10.8 117.8,10.8 117.82,10.81 122.08,10.81 123.58,12.3 143.85,12.3 146.73,15.19 149.52,15.19 149.53,15.2 152.22,15.2 152.23,15.19 162.1,15.19 162.36,14.93 162.91,14.38 165.61,14.38 168.02,11.96 175.96,11.96 177.69,13.68 178.83,13.68 179.73,14.58 179.73,14.58 181.02,15.87 181.02,18.08 185.31,22.36 188.4,22.36 188.92,22.89 v2(189.33,22.89) ; v2(21.87,48.44) 19.84,46.41 18.18,46.41 17.84,46.07 U27.4 ; v2(42.09,76.48) 42.09,76.22 41.17,75.29 41.17,72.13 37.49,68.44 37.49,67.39 34.14,64.03 v2(33.81,64.03)
VADJ1: length 6.5
  TOP w0.127: C8742.1 R440.2 61.7,173.21 R28.2 C40.1 62.35,176.03 v1(62.35,176.53) CN2.22
VBOOT: length 1.4
  BOTTOM w0.381: v2(91.55,85.79) 91.2,85.44 PR163.1
  vias: v1(91.24,86.61)
VOLMUTE#: length 256.9
  TOP w0.127: v2(34.03,65.62) 34.23,65.43 35.63,65.43 35.94,65.73 U11.32 ; v2(167.18,14.78) 167.16,14.76 166.34,14.76 D14.2 166.75,15.29 167.89,15.29 D11.1
  IN1 w0.14: v2(83.62,12.83) 83.6,12.84 82.79,12.84 81.94,11.99 70.76,11.99 67.17,15.58 57.23,15.58 56.48,14.83 44.75,14.83 43.1,16.48 35.02,16.48 28.37,23.12 28.37,23.14 27.99,23.52 27.99,27.1 24.34,30.75 24.34,37.19 19.22,42.31 19.22,47.19 21.12,49.09 21.38,49.09 26.22,53.93 26.22,56.84 32.92,63.53 32.92,64.51 v2(34.03,65.62)
  BOTTOM w0.127: D13.2 202.23,17.51 202.23,22.22 201.91,22.54 201.81,22.54 200.81,23.55 199.07,23.55 198.78,23.84 191.41,23.84 191.15,23.58 185.51,23.58 184.8,22.87 184.8,22.57 180.52,18.29 180.52,16.08 179.52,15.09 179.52,15.09 178.62,14.19 177.44,14.19 175.72,12.47 168.68,12.47 167.64,13.51 167.64,14.33 v2(167.18,14.78) 167.08,14.88 163.12,14.88 162.3,15.71 146.39,15.71 144.11,13.44 120.85,13.44 119.05,11.63 108.68,11.63 108.11,11.06 95.36,11.06 94.35,12.07 90.7,12.07 90.02,12.75 90.02,13.59 88.44,15.16 v1(86.89,15.16) 85.95,15.16 v2(83.62,12.83)
VR_HOT#: length 3.1
  TOP w0.127: PR86.1 97.97,82.35 v1(97.31,83.01) 97.12,83.2 PU3.2
VR_RDY: length 3.7
  TOP w0.127: PR76.1 97.97,86.41 v1(97.33,85.78) 97.33,85.41 96.72,84.8 PU3.6
VR_SVID_ALERT#: length 33.8
  TOP w0.127: PR82.2 101.56,84.07 104.85,84.07 v1(105.18,83.74) 105.56,83.36 108.11,83.36 112.31,87.56 112.31,88.15 114.76,90.6 114.76,93.22 115.75,94.21 116.95,94.21 119.18,96.44 121.67,96.44 122.15,96.93 v2(123.24,96.93)
  BOTTOM w0.127: R531.2 123.94,96.93 v2(123.24,96.93) 122.49,96.18 R533.2 121.29,96.96 C718.2
VR_SVID_CLK: length 37
  TOP w0.127: PR79.2 101.25,85.16 101.93,84.48 106.86,84.48 v1(107.21,84.13) 108.51,84.13 112.05,87.66 112.05,88.44 114.37,90.76 114.37,93.38 115.59,94.59 116.79,94.59 119.02,96.83 121.51,96.83 123.16,98.48 126.45,98.48 v2(126.89,98.04)
  BOTTOM w0.127: U25.N63 129.14,98.48 127.32,98.48 v2(126.89,98.04)
VR_SVID_DATA: length 39.7
  TOP w0.127: v2(125.85,98.02) 124.96,98.02 123.42,96.48 122.07,96.48 121.78,96.19 119.29,96.19 116.87,93.78 115.67,93.78 115.01,93.11 115.01,90.5 112.56,88.05 112.56,86.53 108.82,82.79 103.67,82.79 v1(103.1,83.36) PR84.2
  BOTTOM w0.127: v2(125.85,98.02) 125.08,98.02 R521.2 125.5,98.85 126.77,98.85 127.38,99.46 128.9,99.46 U25.L63
VREFOUT_C: length 4.9
  TOP w0.127: v2(184.41,6.3) 184.36,6.36 184.36,7.74 R430.1
  TOP w0.254: U20.23 186.68,9.04 C585.1 R430.1
VRON: length 56.6
  TOP w0.127: U11.83 53.35,72.93 54,73.58 54,75.87 55.52,77.39 57.05,77.39 58.57,78.92 59.36,78.92 v1(59.64,79.2) 59.89,79.2 61.64,80.95 63.44,80.95 v2(64.04,81.55) ; v2(99.85,80.7) 99.85,81.2 99.72,81.33 PR89.2
  IN1 w0.14: v2(64.04,81.55) 64.25,81.75 65.39,81.75 66.76,83.12 71.5,83.12 72.32,83.95 74.55,83.95 75.06,84.46 76.29,84.46 78.24,82.51 80.85,82.51 82.83,80.54 91.11,80.54 91.34,80.32 93.53,80.32 93.75,80.54 99.69,80.54 v2(99.85,80.7)
WIRELESS_OFF: length 107.4
  TOP w0.127: v2(27.91,22.94) 28.01,22.83 28.01,13.87 33.89,7.99 35.52,7.99 EC71.1 36.35,7.93 Q30.2 37.31,11.3 R414.2 ; U11.78 53.68,70.93 v2(53.92,71.17) 54.31,71.56 v2(54.31,71.68)
  IN1 w0.14: v2(27.91,22.94) 27.72,23.13 27.72,26.99 24.07,30.64 24.07,37.08 18.96,42.2 18.96,47.3 21.05,49.39 21.3,49.39 25.96,54.04 25.96,56.95 32.59,63.59 32.59,67.04 34.57,69.01 34.87,69.01 35.13,69.27 35.13,69.7 34.57,70.26 34.57,70.74 35.62,71.79 38.88,71.79 39.26,71.41 40.72,71.41 41.16,71.41 42.35,72.61 52.49,72.61 52.96,72.14 v2(53.92,71.17)
WIRELESS_OFF_R: length 7.2
  TOP w0.127: CN13.2 40.03,15.5 39.77,15.25 39.77,14 39.39,13.61 R413.1 39.11,12.75 R414.1 38.23,10.95 37.97,10.69 Q30.3
WIRELESS_ON: length 94.2
  TOP w0.127: U11.76 51.59,70.13 51.15,69.7 v2(51.15,68.55) ; R409.2 37.11,13.13 37.74,13.77 37.74,14.96 Q28.2 36.85,16.43 EC56.1 36.09,16.82 35.58,16.31 31.39,16.31 28.5,19.2 v2(28.5,24.94)
  IN1 w0.14: v2(28.5,24.94) 28.49,24.95 28.49,26.97 24.78,30.68 24.78,37.13 19.49,42.42 19.49,47.08 21.23,48.82 21.49,48.82 26.49,53.82 26.49,56.73 33.3,63.54 33.3,64.44 33.81,64.95 34.04,64.95 36.4,67.3 36.4,68.71 37.68,69.99 42.02,69.99 43.05,68.96 46.25,68.96 46.61,69.32 48.99,69.32 49.86,68.45 51.05,68.45 v2(51.15,68.55)
WIRELESS_ON_R: length 12.2
  TOP w0.127: R422.1 36.85,8.69 37.06,8.89 37.06,10.53 36.16,11.43 36.16,12.31 36.43,12.59 37.68,12.59 R409.1 38.23,14.58 Q28.3 39.04,15.39 39.04,15.77 39.76,16.5 CN13.3
XCLK_BIASREF: length 14.8
  TOP w0.254: v2(153.69,103.97) 152.51,103.97 151,105.49 151,106.51 151.9,107.42 153.57,107.42 154.98,108.83 v1(154.98,109.78) 154.98,110.43 156.74,112.19 R149.2
  BOTTOM w0.127: U25.C26 153.6,103.89 v2(153.69,103.97)
XDP_BPM0: length 94.3
  TOP w0.127: CN8.41 71.56,68.64 71.3,68.9 69.66,68.9 68.78,69.78 66.67,69.78 65.96,70.48 65.96,73.96 66.63,74.62 69.52,74.62 69.82,74.32 v2(69.87,74.32)
  IN2 w0.14: v2(69.87,74.32) 70.19,74.63 70.93,74.63 72.73,76.43 74.69,76.43 76.44,78.17 77.45,78.17 79.71,80.44 90.82,80.44 91.62,81.23 93.08,81.23 93.88,80.44 95.67,80.44 99.16,83.93 101.7,83.93 103.25,85.48 103.25,87.56 104.44,88.75 104.44,90.35 109.27,95.17 109.97,95.17 111.93,97.14 111.93,99.98 113.07,101.12 116.34,101.12 116.52,101.3 119.43,101.3 120.06,101.93 128.88,101.93 129.86,100.96 v3(130.29,100.96)
  BOTTOM w0.127: v3(130.29,100.96) 130.27,100.94 130.27,100.4 130.44,100.23 130.82,100.23 131.14,100.54 U25.J60
XDP_BPM1: length 96.5
  TOP w0.127: v2(68.58,74.18) 66.56,74.18 66.23,73.85 66.23,70.59 66.78,70.05 68.89,70.05 69.77,69.16 71.41,69.16 72.06,68.51 CN8.42 72.06,63.99 v1(72.01,63.93)
  IN2 w0.14: v2(130.93,100.95) 130.42,101.47 129.75,101.47 128.34,102.87 120.34,102.87 119.05,101.57 116.41,101.57 116.23,101.4 112.95,101.4 111.65,100.1 111.65,97.25 109.95,95.56 109.24,95.56 104.16,90.48 104.16,88.87 102.97,87.67 102.97,85.6 102.2,84.83 99.66,84.83 96.36,81.53 80.41,81.53 77.33,78.45 76.32,78.45 74.58,76.71 72.61,76.71 70.82,74.91 69.16,74.91 68.58,74.33 v2(68.58,74.18)
  BOTTOM w0.127: U25.H60 131.24,101.25 v2(130.93,100.95)
XDP_DBRESET_N: length 6
  TOP w0.127: v1(80.16,76.89) 80.41,76.63 80.41,75.36 80.02,74.97 R263.1 C362.2 78.89,74.51 78.06,73.68 CN8.7
XDP_PRDY#_CPU: length 84.8
  TOP w0.127: CN8.33 67.56,67.95 67.84,68.23 68.9,68.23 69.16,68.49 69.16,69.02 68.85,69.34 v2(68.59,69.34)
  IN2 w0.14: v2(68.59,69.34) 69.11,69.85 69.11,70.28 69.71,70.89 69.71,72.64 72.95,75.88 74.92,75.88 76.66,77.63 77.67,77.63 79.94,79.89 95.89,79.89 98.65,82.65 101.19,82.65 103.8,85.25 103.8,87.29 105.09,88.58 105.09,90.13 109.38,94.42 110.02,94.42 110.51,94.92 111.3,94.92 111.64,95.27 111.64,96.08 112.48,96.91 112.48,99.75 113.29,100.57 116.57,100.57 116.74,100.74 119.68,100.74 120.32,101.37 121,101.37 121.44,100.93 v3(127.3,100.93)
  BOTTOM w0.076: U25.J62 129.92,100.58 129.62,100.29 127.95,100.29 v3(127.3,100.93)
XDP_PREQ#_CPU: length 82.7
  TOP w0.127: v2(68.71,68.71) 68.66,68.66 67.54,68.66 67.06,68.18 CN8.32
  IN2 w0.14: v2(68.71,68.71) 68.96,68.71 69.37,69.13 69.37,70.17 69.98,70.77 69.98,72.31 71.32,73.66 72.38,73.66 73.2,74.48 73.2,74.81 73.48,75.08 75.25,75.08 76.99,76.83 78.13,76.83 80.14,78.84 95.97,78.84 97.38,80.25 101.43,80.25 105.47,84.29 105.47,87.83 105.99,88.35 105.99,88.81 110.37,93.18 110.82,93.18 113.31,95.67 113.31,96.18 117.03,99.9 128.47,99.9 128.83,99.54 130.2,99.54 v3(130.28,99.46)
  BOTTOM w0.127: v3(130.28,99.46) 130.28,99.49 U25.K62
XDP_RST: length 2.6
  TOP w0.127: CN8.8 77.56,73.85 77.42,73.99 77.42,74.34 77.87,74.8 R262.2
XDP_TDI_CPU: length 61.5
  TOP w0.127: U12.6 86.15,72.5 v2(86.18,72.53)
  BOTTOM w0.127: v2(86.18,72.53) 86.7,72 87.42,72 87.65,72.23 87.65,72.67 87.88,72.89 88.3,72.89 88.62,72.57 98.32,72.57 104.16,78.41 v1(104.8,78.41) 105.68,78.41 118.92,91.65 118.92,96.72 118.97,96.77 118.97,98.6 120.14,99.77 121.07,99.77 R509.2 121.63,100.33 122.22,100.33 122.63,100.74 122.63,101.12 123.59,102.08 U25.F63
XDP_TDO_CPU: length 59.1
  TOP w0.127: U12.3 87.65,72.2 87.89,72.45 v2(88.11,72.45)
  BOTTOM w0.127: v2(88.11,72.45) 88.36,72.45 88.49,72.31 98.58,72.31 103.53,77.27 v1(104.16,77.27) 104.94,77.27 119.28,91.6 119.28,96.43 119.89,97.04 119.89,98.6 120.32,99.03 122.11,99.03 123.2,100.13 123.91,100.13 R506.2 125.46,101.68 128.65,101.68 128.74,101.76 129.42,101.76 129.74,102.08 U25.F62
XDP_TMS_CPU: length 68
  TOP w0.127: U12.8 85.09,69.15 84.86,69.38 v2(84.86,69.71)
  IN2 w0.14: v2(111.08,85.7) 110.89,85.52 110.89,81.59 102.14,72.83 95.58,72.83 94.39,71.65 86.71,71.65 84.86,69.8 v2(84.86,69.71)
  BOTTOM w0.076: U25.E61 130.35,102.87 130.05,103.18 129.46,103.18 129.44,103.2 129.13,103.2 129.08,103.15 128.42,103.15 128.09,103.48 127.46,103.48
  BOTTOM w0.127: 127.46,103.48 122.5,103.48 122.32,103.3 R496.2 121.52,102.87 120.37,102.87 120.11,102.62 120.11,102.18 117.68,99.75 117.68,97.31 117.52,97.16 117.52,92.53 116.36,91.36 116.36,91.33 v1(115.11,90.07) 111.53,86.5 111.53,86.15 v2(111.08,85.7)
XDP_TRST#: length 12.4
  TOP w0.127: U12.12 87.65,67.74 87.77,67.62 87.77,67.17 87.51,66.91 87.14,66.91 86.75,67.29 83.87,67.29 79.56,71.6 CN8.4
XDP_TRST#_CPU: length 75.7
  TOP w0.127: U12.11 87.15,67.53 v2(87.32,67.35)
  IN2 w0.14: v2(87.32,67.35) 87.32,67.18 87.73,66.78 89.36,66.78 v2(93.5,70.92) ; v2(128.76,84.69) 129.61,85.54 129.61,89.41 133.86,93.65 133.86,96.7 133.07,97.49 133.07,102.83 132.6,103.3 131.61,103.3 v2(131.56,103.26)
  BOTTOM w0.089: v2(128.76,84.69) 128.76,85 129.01,85.25 129.54,85.25 U25.AU62
  BOTTOM w0.127: v2(131.56,103.26) 131.89,102.93 U25.E59 ; v2(93.5,70.92) 94.64,72.06 98.7,72.06 102.77,76.12 v1(103.53,76.12) 104.16,76.12 105.56,77.52 R580.2 118.57,77.97 123.87,77.97 128.07,82.16 128.07,83.99 v2(128.76,84.69)
XTAL1: length 3.2
  TOP w0.127: U8.28 22.68,113.48 TP6.1 22.56,113.35 R155.2
XTAL2: length 12.9
  TOP w0.127: U8.29 23.08,112.57 23.07,112.55 23.07,110.23 23.44,109.86 C261.2 23.82,109.47 24.03,109.27 24.46,109.27 24.66,109.07 24.66,107.24 25.47,106.43 Y2.3 25.47,105.24 R159.1 25.04,103.69 v1(25.04,103.68)
XTAL24_IN: length 14
  TOP w0.127: v2(153.53,108.3) 153.53,112.26 R153.1 153.95,112.68 C246.1 153.38,113.46 152.8,114.04 152.8,115.01 Y1.1 154.61,115.27 TP4.1 154.68,116 154.58,116.1 R147.1
  BOTTOM w0.127: v2(153.53,108.3) 153.53,106.41 153.16,106.04 153.16,105.55 U25.A25
XTAL24_OUT: length 15.5
  TOP w0.127: v2(152.51,108.27) 152.93,108.7 R153.2 152.93,113.21 C245.1 152.66,113.46 152.15,113.98 152.15,116.68 Y1.3 151.34,117.45 TP5.1
  BOTTOM w0.127: v2(152.51,108.27) 152.51,107.82 153.29,107.03 153.29,106.51 152.88,106.09 152.88,105.38 153.2,105.06 U25.B25
ZERO_ODD_DP#: length 71.8
  TOP w0.127: ODD15.8 193.68,85.05 194.92,86.28 197.89,86.28 198.14,86.54 198.14,93.19 201.01,96.06 201.01,96.75 200.61,97.16 R166.1 197.99,98.49 ODD14.8 198.8,98.84 197.25,100.38 197.25,103.05 197,103.3 193.83,103.3 193.19,103.94 193.19,106.02 191.44,107.77 v2(191.44,108.1) ; v2(173.81,93.32) 174.07,93.58 176.74,93.58 177.01,93.85 178.41,93.85 179.4,94.84 182.24,94.84 185.11,97.71 186.51,97.71 187.73,98.94 187.73,105.96 187.53,106.17 187.53,107.04 v1(186.82,107.75) 186.59,107.98 v2(186.59,108.86)
  IN1 w0.14: v2(186.59,108.86) 187.11,108.34 191.2,108.34 v2(191.44,108.1)
  BOTTOM w0.127: v2(173.81,93.32) 173.35,93.78 R553.1
ZERO_PWR_ODD: length 310
  TOP w0.127: v2(196.21,99.34) Q37.2 195.6,102.18 194.56,101.14 194.33,101.14 v1(192.94,99.75) 192.94,96.42 191.41,94.9 191.41,94.03 190.63,93.24 v2(190.55,93.24) ; U11.2 38.42,77.73 39.91,76.24 40.3,76.24 45.31,71.23 45.31,69.42 44.69,68.8 44.69,68.21 v2(44.68,68.19)
  IN1 w0.14: v2(189.17,33.44) 189.18,33.44 189.18,34.35 189.51,34.68 189.51,37.82 188.54,38.78 188.54,41.7 192.59,45.74 192.59,49.95 193.14,50.51 193.14,52.06 193.14,52.5 193.95,53.31 193.95,56.32 193.19,57.08 193.19,58.73 191.81,60.11 191.81,68.41 190.79,69.43 190.79,74.76 190.09,75.45 190.09,77.58 189.54,78.13 188.7,78.98 186.94,78.98 186.16,79.76 186.16,83.81 184.99,84.98 184.99,89.31 188.92,93.24 v2(190.55,93.24) ; v2(169.34,15.21) 169.04,15.52 165.89,15.52 165.8,15.61 163.14,15.61 162.48,16.26 153.47,16.26 153.21,16 140.87,16 138.99,14.12 115.93,14.12 114.36,15.69 111.25,15.69 108.23,12.67 96.15,12.67 95.11,13.72 90.85,13.72 89.7,14.87 81.45,14.87 81.13,15.19 73.04,15.19 63.08,25.15 63.08,26.18 60.27,28.99 60.27,51.18 56.67,54.78 56.67,56.65 52.25,61.07 52.25,62.26 52.41,62.42 52.41,62.93 51.83,63.51 51.83,65.27 50.43,66.66 47.45,66.66 46.42,67.69 45.93,67.69 45.76,67.51 45.37,67.51 45.06,67.82 45.05,67.82 v2(44.68,68.19)
  BOTTOM w0.127: 194.89,97.71 194.6,97.71 EC76.1 ; 194.89,97.71 196.54,97.71 196.75,97.92 196.75,98.81 v2(196.21,99.34) ; 194.89,97.71 Q41.2 ; v2(169.34,15.21) 169.75,14.81 170.74,14.81 171.41,14.14 171.41,13.68 171.87,13.23 175.4,13.23 177.12,14.95 178.26,14.95 178.44,15.13 178.49,15.13 179.2,15.85 179.21,15.85 179.75,16.4 179.75,17.7 178.99,18.47 178.99,21.78 185.84,28.64 185.84,29.44 189.18,32.78 189.18,33.43 v2(189.17,33.44)
N175071: length 4.4
  TOP w0.127: PR100.1 95.72,77.02 v1(95.31,76.61)
  TOP w0.254: PR96.2 PC59.1 PC60.1 PR100.1
N175281: length 4.5
  TOP w0.127: PR91.1 PR89.1 97.71,81.33 v1(97.31,81.74) 97.31,81.97 96.47,82.8 PU3.1
N412685: length 41.3
  TOP w0.254: v2(90.7,87.76) 90.7,88.19 91.21,88.7 PR71.2 PR73.2
  BOTTOM w0.254: v2(90.7,87.76) 90.7,85.65 90.52,85.47 90.41,85.47 89.3,84.36 89.3,80.98 90.9,79.38 95.98,79.38 97.81,81.2 v1(97.81,83.36) 98.32,83.87 102.39,83.87 103.4,84.89 108.03,84.89 110.34,87.19 110.34,92.32 PR162.1
N17144302: length 8.4
  TOP w0.127: v1(145.31,20.88) Q25.2
  TOP w0.254: R381.2 141.59,22.63 Q26.3 143.31,22.79 C533.2 145.94,22.79 146.58,22.15 Q25.2
N17248901: length 17.6
  BOTTOM w0.127: Q39.2 190.52,95.56 191.1,96.13 191.1,99.3 192.17,100.37 C717.1 192.17,101.52 R497.1 191.9,102.02 R498.2 193.83,103.95 v1(193.83,104.19) 193.83,104.33 194.17,104.67 194.17,104.69 194.45,104.98 195.04,104.98 195.96,104.06 195.96,102.24 195.54,101.82 Q41.6
N17249052: length 3.8
  BOTTOM w0.127: Q41.3 194.24,99.95 193.7,100.49 193.7,101.57 v2(193.52,101.75) 193.25,102.02 R498.1
N17254457: length 3.7
  TOP w0.127: C542.2 88.93,19.37 88.24,20.07 v1(87.83,20.07) 87.4,20.5 R391.1
N17254462: length 2.6
  TOP w0.127: R376.2 75.51,21.85 v2(76.1,21.85) U18.6
N17256569: length 8.5
  TOP w0.127: v1(166.14,133.15) 166.15,133.16 R315.2
  TOP w0.254: Q20.2 167.16,134.29 R315.2 169.43,133.16 Q21.3 170.33,132.89 170.97,133.54 R303.1
N17259008: length 2.4
  TOP w0.127: R309.2 189.04,57.57 v1(188.87,57.73) 188.54,57.4 U13.7
