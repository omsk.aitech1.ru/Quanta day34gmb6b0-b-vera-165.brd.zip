# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_BS#1: length 65
  IN2 w0.089: v2(147.48,80.53) 147.88,80.13 147.88,77.38 147.32,76.82 147.32,75.89 147.88,75.33 147.88,74.94 147.6,74.65
  IN2 w0.216: 147.6,74.65 147.11,74.16 147.11,62.8 148.25,61.66 148.25,60.22 149.35,59.12 149.35,54.71 147.55,52.91 147.55,48.51 147.87,48.19 147.87,46 147.39,45.52 147.39,40.08 148.14,39.33 148.14,33.91 147.66,33.43 147.66,32.43 147.22,31.99 147.22,29.85 v4(147.12,29.74)
  BOTTOM w0.076: U25.AV35 146.77,83.89 146.77,81.24 v2(147.48,80.53)
  BOTTOM w0.191: v4(147.12,29.74) 147.12,30.56 146.92,30.75 146.55,30.75 146.36,30.56 146.36,28.87 146.85,28.38 JDIM2.108
M_A_BS#2: length 62.2
  IN2 w0.089: v2(142.64,82.29) 141.04,80.68 141.04,79.63 139.33,77.92 138.88,77.92 138.16,77.2 138.16,77.1
  IN2 w0.216: v4(135.86,30.74) 135.72,30.87 135.72,32.07 135.34,32.45 135.34,39.08 134.43,39.99 134.43,40.11 134.43,48.54 135.11,49.22 135.11,52.51 134.36,53.26 134.36,57.84 135.32,58.79 135.32,66.22 135.7,66.61 135.7,71.31 136.27,71.87 136.27,72.9 137.43,74.06 138.16,74.79 138.16,77.1
  BOTTOM w0.089: U25.AY41 142.64,82.36 v2(142.64,82.29)
  BOTTOM w0.191: v4(135.86,30.74) 136.82,31.7 136.82,32.56 137.18,32.92 137.95,32.92 138.15,33.12 JDIM2.79
M_A_CAS#: length 62.4
  IN2 w0.089: v2(147.49,84.54) 147.49,84.81 147.58,84.9 148.15,84.9 148.45,84.6 148.45,84.1 148.26,83.92 148.26,83.29 148.42,83.13 148.42,74.18 149.09,73.51 149.09,73.03
  IN2 w0.216: 149.09,73.03 149.09,64.49 149.55,64.03 149.55,63.53 149.34,63.33 149.34,63.08 149.57,62.85 150.72,62.85 150.91,62.66 150.91,62.39 150.72,62.2 150.27,62.2 150.08,62.01 150.08,61.75 150.27,61.56 150.72,61.56 150.91,61.37 150.91,61.1 150.72,60.91 150.42,60.91 150.23,60.72 150.23,60.45 150.42,60.26 150.74,60.26 150.91,60.09 150.91,53.71 150.45,53.25 150.17,53.25 149.98,53.06 149.98,52.79 150.17,52.6 150.34,52.6 150.53,52.42 150.53,52.14 150.34,51.95 150.16,51.95 149.98,51.77 149.98,51.51 150.16,51.33 150.35,51.33 150.52,51.16 150.52,50.91 150.35,50.73 150.15,50.73 149.98,50.57 149.98,47.68 149.61,47.31 149.61,43.9 150.23,43.28 150.23,39.92 149.71,39.4 149.71,33 149.49,32.78 v4(149.23,32.78)
  BOTTOM w0.089: v2(147.49,84.54) 147.64,84.54 U25.AU34
  BOTTOM w0.191: JDIM2.115 148.95,33.06 v4(149.23,32.78)
M_A_CKE0: length 62.7
  IN2 w0.089: 137.85,76.81 137.85,77.15 138.8,78.1 139.25,78.1 140.86,79.71 140.86,80.83 141.88,81.86 141.88,83.9 v2(141.19,84.59)
  IN2 w0.216: 137.85,76.81 137.85,74.97 135.5,72.61 135.5,72.13 134.98,71.61 134.98,67.12 134.36,66.5 134.36,66.02 134.59,65.79 134.59,65.33 134.36,65.1 134.36,64.59 134.59,64.36 134.59,63.91 134.36,63.68 134.36,62.74 134.57,62.54 134.57,61.6 134.36,61.39 134.36,60.45 134.57,60.25 134.57,59.07 133.63,58.14 133.63,52.96 134.08,52.51 134.08,52.11 133.63,51.66 133.63,51.38 134.11,50.9 134.11,50.57 133.63,50.1 133.63,49.73 133.88,49.48 133.88,49.01 133.63,48.77 133.63,39.76 134.59,38.81 134.59,32.13 v4(134.87,31.85)
  BOTTOM w0.089: v2(141.19,84.59) 141.39,84.59 U25.AU43
  BOTTOM w0.191: JDIM2.73 136.35,33.01 135.19,31.85 v4(134.87,31.85)
M_A_CKE1: length 62.8
  IN2 w0.089: v2(141.19,83.21) 140.6,82.62 140.6,79.7 139.18,78.28 138.73,78.28 137.53,77.08
  IN2 w0.216: v4(136.33,27.72) 134.07,29.97 134.07,38.59 133.11,39.55 133.11,58.35 133.71,58.95 133.71,66.91 134.46,67.65 134.46,71.82 134.98,72.35 134.98,72.7 136.27,73.99 137.53,75.24 137.53,77.08
  BOTTOM w0.089: U25.AW43 141.27,83.21 v2(141.19,83.21)
  BOTTOM w0.191: JDIM2.74 136.65,27.39 v4(136.33,27.72)
M_A_CLKN0: length 65.7
  IN2 w0.089: v2(145.96,80.02) 146.15,80.21 146.35,80.21 146.43,80.14 146.43,79.82 145.95,79.35 145.95,79.11 145.91,79.07 145.91,79.05
  IN2 w0.14: 145.91,79.05 145.91,78.5 144.52,77.11 144.52,62.01 145.8,60.73 145.8,54.79 144.65,53.65 144.65,39.22 145.76,38.12 145.76,37.1 145.27,36.62 145.27,34.99 145.08,34.8 144.66,34.8 144.35,34.49 144.35,33.93 144.66,33.62 144.95,33.62 145.1,33.47 145.1,33.12 144.95,32.97 144.63,32.97 144.28,32.62 144.28,32.3 143.64,31.67 143.64,31.04 143.95,30.74 145.1,30.74 v4(145.22,30.62)
  BOTTOM w0.076: U25.AU37 145.44,84.57 145.03,84.16 145.03,80.51 145.29,80.25 145.73,80.25 v2(145.96,80.02)
  BOTTOM w0.127: v4(145.22,30.62) 145.22,30.98 145.36,31.12 145.56,31.12 145.9,31.45 145.9,32.64 145.35,33.19 JDIM2.103
M_A_CLKN1: length 64.1
  IN2 w0.089: 147.09,79.05 147.09,79.07 147.05,79.11 147.05,82.49 146.63,82.91 146.14,82.91 145.89,83.16 v2(145.89,83.21)
  IN2 w0.14: 147.09,79.05 147.09,77.96 146.05,76.92 146.05,74.88 145.71,74.54 145.71,62.5 146.98,61.22 146.98,54.31 145.85,53.17 145.85,49.02 146.15,48.72 146.15,48.2 146.66,47.69 146.66,47.12 146.36,46.81 145.98,46.81 145.83,46.66 145.83,39.71 146.94,38.61 146.94,34.41 146.28,33.75 146.28,28.91 145.81,28.44 145.58,28.44 145.41,28.26 v4(145.41,28.08)
  BOTTOM w0.076: v2(145.89,83.21) 146.21,83.54 U25.AW36
  BOTTOM w0.127: v4(145.41,28.08) 145.4,28.08 145.4,28.5 145.3,28.6 144.98,28.6 144.75,28.38 144.75,28.02 145.65,27.12 JDIM2.104
M_A_CLKP0: length 65.3
  IN2 w0.089: v2(145.96,80.65) 145.96,80.59 146.16,80.39 146.43,80.39 146.61,80.21 146.61,79.75 146.13,79.27 146.13,79.11 146.18,79.07 146.18,79.05
  IN2 w0.14: 146.18,79.05 146.18,78.38 144.79,77 144.79,62.12 146.07,60.84 146.07,54.68 144.92,53.53 144.92,39.33 146.02,38.23 146.02,36.99 145.54,36.51 145.54,34.88 145.19,34.53 144.77,34.53 144.62,34.38 144.62,34.04 144.77,33.88 145.06,33.88 145.37,33.58 145.37,33.01 145.06,32.7 144.74,32.7 144.54,32.51 144.54,32.19 143.91,31.56 143.91,31.16 144.06,31 144.99,31 145.22,31.23 v4(145.22,31.89)
  BOTTOM w0.076: U25.AV37 145.29,84.19 145.2,84.09 145.2,80.58 145.36,80.42 145.72,80.42 v2(145.96,80.65)
  BOTTOM w0.127: JDIM2.101 144.75,33.35 145.06,33.05 145.17,33.05 145.19,33.02 145.67,32.54 145.67,31.55 145.47,31.34 145.34,31.34 145.22,31.46 v4(145.22,31.89)
M_A_CLKP1: length 63.8
  IN2 w0.089: v2(145.91,82.56) 146.08,82.73 146.56,82.73 146.87,82.42 146.87,79.11 146.82,79.07 146.82,79.05
  IN2 w0.14: 146.82,79.05 146.82,78.07 145.78,77.03 145.78,74.99 145.44,74.65 145.44,62.39 146.71,61.11 146.71,54.42 145.58,53.28 145.58,48.91 145.88,48.61 145.88,48.09 146.4,47.57 146.4,47.23 146.24,47.08 145.87,47.08 145.57,46.77 145.57,39.6 146.67,38.5 146.67,34.52 146.02,33.86 146.02,29.02 145.7,28.7 145.51,28.7 145.37,28.85 v4(145.37,29.35)
  BOTTOM w0.076: U25.AY36 145.99,82.56 v2(145.91,82.56)
  BOTTOM w0.127: v4(145.37,29.35) 145.37,28.95 145.25,28.83 144.88,28.83 144.88,28.83 144.52,28.47 144.52,27.92 145.11,27.34 145.11,27.23 145.05,27.17 JDIM2.102
M_A_CS#0: length 65.3
  IN2 w0.089: 151.22,72.06 151.22,72.66 148.98,74.91 148.98,84.82 148.28,85.52 148.28,85.91 v2(148.69,86.32)
  IN2 w0.216: 151.22,72.06 151.22,64.85 152.67,63.4 152.67,52.78 152.46,52.57 152.46,47.66 151.55,46.76 151.55,44.46 152.47,43.54 152.47,39.67 151.49,38.68 151.49,31.07 150.15,29.74 150.15,29.25 v4(149.41,28.51)
  BOTTOM w0.076: v2(148.69,86.32) 148.37,86.65 U25.AP33
  BOTTOM w0.191: JDIM2.114 148.65,27.74 v4(149.41,28.51)
M_A_CS#1: length 65.4
  IN2 w0.089: 151.87,71.62 151.87,72.33 149.16,75.04 149.16,85.21 v2(148.69,85.68)
  IN2 w0.216: 151.87,71.62 151.87,64.94 153.2,63.61 153.2,47.65 152.56,47.01 152.56,44.19 153.02,43.73 153.02,39.31 152.01,38.3 152.01,29.45 151.83,29.27 151.46,29.27 151.31,29.43 v4(151.31,30.09)
  BOTTOM w0.076: U25.AR32 149.01,86 v2(148.69,85.68)
  BOTTOM w0.191: v4(151.31,30.09) 151.31,32.41 150.75,32.97 JDIM2.121
M_A_DQ0: length 78.9
  IN2 w0.14: v2(125.61,90.69) 125.39,90.91 121.99,90.91 121.58,90.49 119.64,90.49 113.84,84.69 113.84,66.13 112.99,65.27 112.99,52.38 112.2,51.59 112.2,35.77 113.05,34.92 113.05,31.66 113.59,31.12 113.59,30.35 113.05,29.82 113.05,29.08 v4(113.16,28.97)
  BOTTOM w0.076: 126.86,90.27 127.18,90.27 127.44,90.02 128.6,90.02 128.82,90.24 U25.AH63
  BOTTOM w0.127: JDIM2.6 113.85,28.28 v4(113.16,28.97) ; v2(125.61,90.69) 126.44,90.69 126.86,90.27
M_A_DQ1: length 79.9
  IN2 w0.14: v2(126.96,90.76) 126.59,91.14 125.8,91.14 125.69,91.25 121.85,91.25 121.53,90.93 119.59,90.93 113.5,84.84 113.5,66.27 112.64,65.41 112.64,52.52 111.84,51.72 111.84,35.64 112.71,34.78 112.71,28.01 113.25,27.48 v4(113.25,27.48)
  BOTTOM w0.076: v2(126.96,90.76) 127.54,90.18 128.53,90.18 128.88,90.53 129.36,90.53 129.53,90.44 129.73,90.24 U25.AH62
  BOTTOM w0.127: JDIM2.4 v4(113.25,27.48)
M_A_DQ2: length 78.2
  IN2 w0.14: v2(125.19,88.93) 124.87,88.93 124.56,88.62 122.36,88.62 121.91,88.17 120.14,88.17 116.01,84.05 116.01,60.84 115.89,60.71 115.24,60.71 115.12,60.59 115.12,60.42 115.24,60.3 115.89,60.3 116.01,60.17 116.01,60 115.89,59.88 115.12,59.88 114.99,59.75 114.99,59.58 115.12,59.46 115.89,59.46 116.01,59.33 116.01,59.16 115.89,59.04 115.12,59.04 114.99,58.92 114.99,48.8 114.67,48.47 114.67,44.18 115.06,43.79 115.06,39.22 115.48,38.8 115.48,31.32 v4(116.21,30.59)
  BOTTOM w0.076: U25.AK63 129.16,88.76 128.66,88.76 128.25,88.35 126.94,88.35 126.76,88.53 125.57,88.53 125.53,88.57
  BOTTOM w0.127: 125.53,88.57 125.19,88.92 v2(125.19,88.93) ; JDIM2.17 117.15,31.53 v4(116.21,30.59)
M_A_DQ3: length 78.7
  IN2 w0.14: v4(117.45,27.5) 116.84,28.11 116.84,37.16 116.23,37.77 116.23,39.04 115.77,39.5 115.77,44.05 115.42,44.41 115.42,48.25 115.68,48.51 115.68,53.06 115.8,53.18 116.69,53.18 116.81,53.3 116.81,53.48 116.69,53.6 115.8,53.6 115.68,53.72 115.68,53.9 115.8,54.02 116.69,54.02 116.81,54.14 116.81,54.32 116.69,54.44 116,54.44 115.88,54.56 115.88,54.73 116,54.86 116.69,54.86 116.81,54.98 116.81,83.87 120.43,87.49 122.2,87.49 122.64,87.93 125.22,87.93 v2(125.26,87.97)
  BOTTOM w0.076: U25.AK62 129.7,88.89 129.41,88.59 128.78,88.59 128.37,88.18 126.87,88.18 126.69,88.36 125.7,88.36 125.53,88.19
  BOTTOM w0.127: JDIM2.18 v4(117.45,27.5) ; 125.53,88.19 125.31,87.97 v2(125.26,87.97)
M_A_DQ4: length 79.9
  IN2 w0.14: v2(127.14,89.01) 127.14,89.48 126.95,89.66 125.3,89.66 124.74,90.22 122.28,90.22 121.86,89.81 119.92,89.81 114.53,84.41 114.53,64.07 114.4,63.95 113.79,63.95 113.67,63.83 113.67,63.65 113.79,63.53 114.4,63.53 114.53,63.41 114.53,63.23 114.4,63.11 113.79,63.11 113.67,62.99 113.67,62.81 113.79,62.69 114.4,62.69 114.53,62.57 114.53,62.39 114.4,62.27 113.79,62.27 113.67,62.15 113.67,61.98 113.79,61.85 114.06,61.85 114.18,61.73 114.18,61.56 114.06,61.43 113.79,61.43 113.67,61.31 113.67,49.32 112.93,48.58 112.93,36.02 114.15,34.8 v4(114.15,32.68)
  BOTTOM w0.076: U25.AH61 130.65,90.24 131.2,89.68 131.2,89.44 131.03,89.27 130.79,89.27 130.77,89.28 130.4,89.28 130.38,89.27 130.19,89.27 130.18,89.28 130.04,89.34 129.83,89.34 129.68,89.27 129.55,89.27 129.44,89.32 129.39,89.34 129.1,89.34 128.84,89.09 128.52,89.09 128.12,88.69 127.46,88.69 v2(127.14,89.01)
  BOTTOM w0.127: JDIM2.7 v4(114.15,32.68)
M_A_DQ5: length 80.7
  IN2 w0.14: v2(127.6,90.76) 127.6,90.38 127.36,90.14 125.41,90.14 124.98,90.57 122.13,90.57 121.72,90.15 119.78,90.15 114.18,84.55 114.18,65.37 114.06,65.25 113.45,65.25 113.33,65.13 113.33,64.96 113.45,64.83 114.06,64.83 114.18,64.71 114.18,64.54 114.06,64.41 113.45,64.41 113.33,64.29 113.33,49.47 112.57,48.71 112.57,35.89 113.65,34.81 113.65,31.55 v4(114.14,31.06)
  BOTTOM w0.076: U25.AH60 130.85,90.62 129.54,90.62 129.4,90.69 128.81,90.69 128.47,90.35 128,90.35 v2(127.6,90.76)
  BOTTOM w0.127: JDIM2.5 113.55,31.65 v4(114.14,31.06)
M_A_DQ6: length 79.2
  IN2 w0.14: v4(116.21,32.11) 115.82,32.5 115.82,38.94 115.42,39.34 115.42,43.92 115.05,44.28 115.05,48.37 115.34,48.65 115.34,55.2 115.46,55.32 116.25,55.32 116.38,55.45 116.38,55.62 116.25,55.74 115.46,55.74 115.34,55.86 115.34,56.04 115.46,56.16 116.25,56.16 116.37,56.28 116.37,56.46 116.25,56.58 115.46,56.58 115.34,56.7 115.34,56.88 115.46,57 116.24,57 116.37,57.12 116.37,57.3 116.24,57.42 115.46,57.42 115.34,57.54 115.34,57.71 115.46,57.84 116.25,57.84 116.37,57.96 116.37,58.13 116.25,58.26 115.6,58.26 115.47,58.38 115.47,58.55 115.6,58.68 116.2,58.68 116.36,58.83 116.36,83.9 120.28,87.83 122.05,87.83 122.5,88.27 124.75,88.27 124.96,88.48 126.03,88.48 126.48,88.93 v2(126.48,88.93)
  BOTTOM w0.076: U25.AK61 130.24,88.99 130.11,89.13 130,89.18 129.87,89.18 129.85,89.17 129.77,89.13 129.71,89.1 129.51,89.1 129.35,89.18 129.16,89.18 128.91,88.92 128.59,88.92 128.18,88.52 127.01,88.52 126.59,88.93 v2(126.48,88.93)
  BOTTOM w0.127: JDIM2.15 116.55,32.45 v4(116.21,32.11)
M_A_DQ7: length 80.1
  IN2 w0.14: v2(126.53,87.97) 126.53,87.97 126.04,87.48 124.99,87.48 124.88,87.59 122.78,87.59 122.34,87.15 120.57,87.15 117.15,83.73 117.15,52.89 117.03,52.76 116.15,52.76 116.02,52.64 116.02,52.47 116.15,52.35 117.03,52.35 117.15,52.22 117.15,52.05 117.03,51.93 116.15,51.93 116.02,51.8 116.02,51.63 116.15,51.51 116.73,51.51 116.9,51.34 116.9,49.24 115.76,48.1 115.76,44.55 116.11,44.19 116.11,39.64 116.57,39.18 116.57,38.01 117.22,37.36 117.22,35.61 117.35,35.48 117.72,35.48 117.85,35.36 117.85,35.19 117.72,35.06 117.35,35.06 117.22,34.94 117.22,29.42 v4(117.44,29.2)
  BOTTOM w0.076: U25.AK60 131,88.99 130.71,88.7 130.46,88.7 130.45,88.72 130.18,88.72 130.06,88.59 129.64,88.59 129.48,88.43 128.85,88.43 128.44,88.02 126.58,88.02 v2(126.53,87.97)
  BOTTOM w0.127: v4(117.44,29.2) 116.85,28.61 JDIM2.16
M_A_DQ8: length 71.8
  IN2 w0.14: v4(119.25,27.48) 119.89,28.12 119.89,33.48 119.48,33.89 119.48,37.37 118.15,38.7 118.15,43.25 117.77,43.63 117.77,46.49 118.72,47.45 118.72,50.95 119.06,51.29 119.06,83.45 121.2,85.58 125.24,85.58 v2(125.87,86.21)
  BOTTOM w0.076: U25.AM63 128.92,87.81 128.63,87.51 127.09,87.51 126.79,87.21 125.93,87.21 125.7,86.98 125.7,86.59
  BOTTOM w0.127: JDIM2.24 119.25,27.47 v4(119.25,27.48) ; 125.7,86.59 125.7,86.38 v2(125.87,86.21)
M_A_DQ9: length 72.6
  IN2 w0.14: v2(125.28,86.81) 124.4,85.93 121.06,85.93 118.71,83.58 118.71,51.42 118.38,51.09 118.38,47.59 117.42,46.64 117.42,43.49 117.8,43.1 117.8,38.56 119.13,37.23 119.13,33.75 119.51,33.37 119.51,29.2 119.39,29.08 v4(119.25,29.08)
  BOTTOM w0.076: 125.53,87.06 125.84,87.37 126.72,87.37 127.02,87.67 128.56,87.67 128.98,88.1 129.41,88.1 129.7,87.81 U25.AM62
  BOTTOM w0.127: v4(119.25,29.08) 118.65,28.48 JDIM2.22 ; 125.53,87.06 v2(125.28,86.81)
M_A_DQ10: length 70.4
  IN2 w0.14: v2(127.32,85.51) 127.32,85.61 127.71,86 128.29,86 128.53,85.77 128.53,85.42 128.1,84.98 128.1,83.59 128.53,83.16 128.53,79.64 122.87,73.98 122.87,57.57 122.75,57.45 121.95,57.45 121.83,57.33 121.83,57.15 121.95,57.03 122.75,57.03 122.87,56.91 122.87,56.73 122.75,56.61 121.83,56.61 121.7,56.49 121.7,47.13 121.24,46.67 121.24,39.43 122.61,38.07 122.61,35.2 123.19,34.62 123.19,27.97 v4(122.7,27.48)
  BOTTOM w0.076: v2(127.32,85.51) 127.76,85.95 128.64,85.95 129.14,86.45 U25.AP63
  BOTTOM w0.127: v4(122.7,27.48) 122.85,27.33 JDIM2.36
M_A_DQ11: length 71.4
  IN2 w0.14: v2(128.03,85.55) 127.75,85.28 127.75,79.55 122.53,74.32 122.53,59.71 122.4,59.59 121.48,59.59 121.36,59.47 121.36,59.29 121.48,59.17 122.4,59.17 122.53,59.05 122.53,58.87 122.4,58.75 121.48,58.75 121.36,58.63 121.36,58.46 121.48,58.33 122.4,58.33 122.53,58.21 122.53,58.04 122.4,57.91 121.48,57.91 121.36,57.79 121.36,47.27 120.18,46.08 120.18,43.25 120.85,42.57 120.85,39.34 122.23,37.96 122.23,35.1 122.81,34.51 122.81,30.84 122.15,30.18 122.15,29.7 v4(122.7,29.15)
  BOTTOM w0.076: v2(128.03,85.55) 128.47,85.55 129.08,86.16 129.41,86.16 129.7,86.45 U25.AP62
  BOTTOM w0.127: JDIM2.34 122.25,28.7 v4(122.7,29.15)
M_A_DQ12: length 73.1
  IN2 w0.14: v2(124.34,87.07) 123.56,86.28 120.93,86.28 118.35,83.71 118.35,51.55 117.9,51.1 117.9,47.6 117.07,46.76 117.07,43.33 117.45,42.95 117.45,38.41 118.75,37.1 118.75,33.62 119.13,33.24 119.13,30.75 118.98,30.61 118.77,30.61 118.62,30.75 v4(118.62,31.16)
  BOTTOM w0.076: U25.AM61 130.46,87.7 130.06,88.1 129.64,88.1 129.48,88.26 128.91,88.26 128.49,87.84 126.96,87.84 126.65,87.54 125.73,87.54 125.64,87.44 125.53,87.44
  BOTTOM w0.127: v4(118.62,31.16) 119.13,31.67 119.13,32.87 118.95,33.05 JDIM2.23 ; v2(124.34,87.07) 124.72,87.44 125.53,87.44
M_A_DQ13: length 74.2
  IN2 w0.14: v4(118.62,32.66) 118.41,32.44 118.41,32.04 118.28,31.91 118.07,31.91 117.91,32.07 117.91,32.85 118.37,33.3 118.37,36.98 117.09,38.25 117.09,42.82 116.71,43.2 116.71,47.36 116.93,47.58 117.4,47.58 117.52,47.7 117.52,47.88 117.4,48 116.83,48 116.7,48.13 116.7,48.31 116.83,48.44 117.34,48.44 117.56,48.66 117.56,51.24 118.01,51.69 118.01,83.85 120.78,86.62 122.56,86.62 v2(123,87.07)
  BOTTOM w0.076: U25.AM60 131.24,87.04 131.03,86.84 130.19,86.84 130.18,86.85 130.09,86.89 130.04,86.91 129.83,86.91 129.68,86.84 129.55,86.84 129.39,86.91 129.1,86.91 128.47,86.28 126.85,86.28 126.57,86
  BOTTOM w0.127: 126.57,86 126.33,85.77 125.23,85.77 124.43,86.56 123.5,86.56 v2(123,87.07) ; JDIM2.21 118.35,32.93 v4(118.62,32.66)
M_A_DQ14: length 71.6
  IN2 w0.14: v2(126.45,84.89) 126.45,84.5 126.96,83.99 126.96,79.77 121.84,74.65 121.84,66.51 121.72,66.39 121.12,66.39 121,66.27 121,66.09 121.12,65.97 121.72,65.97 121.84,65.85 121.84,65.67 121.72,65.55 120.8,65.55 120.68,65.43 120.68,65.25 120.8,65.13 121.72,65.13 121.84,65.01 121.84,64.83 121.72,64.71 120.8,64.71 120.68,64.59 120.68,64.42 120.8,64.29 121.72,64.29 121.84,64.17 121.84,64 121.72,63.87 120.8,63.87 120.68,63.75 120.68,63.58 120.8,63.45 121.72,63.45 121.84,63.33 121.84,63.16 121.72,63.04 120.8,63.04 120.65,62.89 120.65,47.53 119.49,46.37 119.49,42.91 119.91,42.49 119.91,39.31 121.47,37.75 121.47,36.37 121.34,36.25 121.19,36.25 121.07,36.13 121.07,35.95 121.19,35.83 121.34,35.83 121.47,35.71 121.47,34.84 121.95,34.36 v4(121.95,32.81)
  BOTTOM w0.076: U25.AP61 130.35,86.45 130.11,86.7 130,86.75 129.87,86.75 129.85,86.74 129.77,86.7 129.71,86.67 129.51,86.67 129.35,86.75 129.16,86.75 128.54,86.12 127.37,86.12 126.77,85.52
  BOTTOM w0.127: v2(126.45,84.89) 126.45,85.2 126.77,85.52 ; JDIM2.33 v4(121.95,32.81)
M_A_DQ15: length 72.8
  IN2 w0.14: v2(127.3,84.29) 127.3,79.6 122.18,74.48 122.18,62.69 122.06,62.57 121.14,62.57 121.02,62.45 121.02,62.27 121.14,62.15 122.06,62.15 122.18,62.03 122.18,61.85 122.06,61.73 121.14,61.73 121.02,61.61 121.02,61.44 121.14,61.31 122.06,61.31 122.18,61.19 122.18,61.02 122.06,60.89 121.14,60.89 121.02,60.77 121.02,60.6 121.14,60.47 122.06,60.47 122.18,60.35 122.18,60.18 122.06,60.06 121.14,60.06 121.02,59.93 121.02,47.41 119.84,46.23 119.84,43.1 120.27,42.67 120.27,39.44 121.85,37.86 121.85,34.97 122.43,34.39 122.43,31.3 122.26,31.13 v4(121.92,31.13)
  BOTTOM w0.076: 128.24,85.09 129.15,86 129.48,86 129.64,86.16 130.06,86.16 130.07,86.17 130.45,86.17 130.46,86.16 130.71,86.16 131,86.45 U25.AP60
  BOTTOM w0.127: 128.24,85.09 127.44,84.29 v2(127.3,84.29) ; v4(121.92,31.13) 122.24,31.13 122.55,31.44 JDIM2.35
M_A_DQ16: length 63.1
  IN2 w0.14: v4(124.65,27.48) 124.94,27.19 125.24,27.19 125.38,27.32 125.38,30.3 125.09,30.59 125.09,35.39 124.57,35.91 124.57,38.32 123.35,39.54 123.35,47.08 123.46,47.19 123.46,52.39 124.58,53.5 124.58,60.88 124.78,61.09 124.78,72.61 126.95,74.77 127.11,74.77 v2(129.69,77.35)
  BOTTOM w0.076: U25.AY58 132.48,82.82 132.25,82.59 132.25,81.75 131.57,81.07 131.57,80.95
  BOTTOM w0.127: 131.57,80.95 131.57,78.43 130.49,77.35 v2(129.69,77.35) ; JDIM2.42 v4(124.65,27.48)
M_A_DQ17: length 63.4
  IN2 w0.14: v4(124.6,29) 124.7,29.1 124.7,35.23 124.23,35.71 124.23,38.15 123.01,39.37 123.01,52.42 124.23,53.65 124.23,72.95 126.58,75.3 127.14,75.3 127.79,75.95 127.79,76.38 128.29,76.89 128.73,76.89 129.11,77.27 129.11,77.9 129.79,78.59 v2(130.22,78.59)
  BOTTOM w0.076: U25.AW58 132.18,83.24 132.18,82.78 132.09,82.68 132.09,81.82 131.28,81.01
  BOTTOM w0.127: JDIM2.40 124.05,28.44 v4(124.6,29) ; v2(130.22,78.59) 130.22,78.59 130.55,78.59 131.19,79.23 131.19,80.92 131.28,81.01
M_A_DQ18: length 63.8
  IN2 w0.14: v2(132.64,78.16) 132.26,78.16 131.46,77.37 131.46,76.76 126.62,71.92 126.62,57.87 126.46,57.71 126.46,52.53 126.3,52.37 126.06,52.37 125.94,52.25 125.94,52.07 126.06,51.95 126.37,51.95 126.49,51.83 126.49,51.66 126.37,51.53 125.94,51.53 125.81,51.41 125.81,48.98 125.94,48.86 126.24,48.86 126.37,48.73 126.37,48.56 126.24,48.44 125.94,48.44 125.81,48.31 125.81,47.04 125.44,46.66 125.44,39.79 127.38,37.84 127.38,30.04 127.91,29.52 127.91,28.27 127.12,27.48 v4(127.05,27.48)
  BOTTOM w0.076: U25.AY56 133.81,82.87 133.81,81.46 132.87,80.53 132.87,80.19
  BOTTOM w0.127: JDIM2.50 v4(127.05,27.48) ; v2(132.64,78.16) 132.64,78.94 132.87,79.18 132.87,80.19
M_A_DQ19: length 64.6
  IN2 w0.14: v2(131.98,77.06) 131.98,76.79 129.5,74.32 129.5,73.87 129.31,73.68 129.31,73.4 129.49,73.21 129.49,73.04 129.37,72.92 128.27,72.92 128.15,72.79 128.15,72.62 128.27,72.5 129.25,72.5 129.37,72.38 129.37,72.2 129.25,72.08 127.65,72.08 127.53,71.96 127.53,71.78 127.65,71.66 129.11,71.66 129.23,71.54 129.23,71.36 129.11,71.24 127.52,71.24 126.96,70.68 126.96,48.22 126.22,47.48 126.22,46.96 125.8,46.54 125.8,39.91 127.77,37.94 127.77,32.5 v4(127.94,32.33)
  BOTTOM w0.076: U25.AW56 133.83,83.3 134.12,83.01 134.12,82.76 133.97,82.62 133.97,81.39 133.21,80.63 133.21,80.19
  BOTTOM w0.127: v4(127.94,32.33) 127.35,32.92 JDIM2.51 ; v2(131.98,77.06) 132.46,77.06 133.09,77.7 133.09,79.04 133.21,79.15 133.21,80.19
M_A_DQ20: length 64.3
  IN2 w0.14: v2(130.74,79.81) 130.5,79.81 127.38,76.68 127.13,76.68 126.3,75.86 126.3,75.64 123.84,73.18 123.84,61.29 123.73,61.18 123.73,54.19 123.61,54.07 123.07,54.07 122.95,53.95 122.95,53.77 123.07,53.65 123.33,53.65 123.46,53.53 123.46,53.35 123.33,53.23 123.05,53.23 122.57,52.75 122.57,46.77 122.11,46.31 122.11,39.79 123.87,38.02 123.87,35.53 124.32,35.08 124.32,30.83 124.17,30.67 123.92,30.67 123.77,30.83 v4(123.77,31)
  BOTTOM w0.076: 131.27,82.32 131.5,82.55 131.5,83.02 132.48,84 U25.AV58
  BOTTOM w0.127: 131.27,82.32 130.74,81.79 v2(130.74,79.81) ; JDIM2.41 124.35,31.59 v4(123.77,31)
M_A_DQ21: length 65.2
  IN2 w0.14: v2(133.03,81.59) 132.94,81.68 132.01,81.68 131.88,81.55 131.51,81.55 123.39,73.43 123.39,56.49 122.99,56.09 122.5,56.09 122.38,55.97 122.38,55.79 122.5,55.67 123.14,55.67 123.26,55.55 123.26,55.37 123.14,55.25 122.36,55.25 122.24,55.13 122.24,54.95 122.36,54.83 123.1,54.83 123.22,54.71 123.22,54.54 123.1,54.41 122.38,54.41 122.23,54.26 122.23,46.91 121.77,46.45 121.77,39.65 123.53,37.88 123.53,35.33 123.77,35.1 v4(123.77,32.48)
  BOTTOM w0.076: v2(133.03,81.59) 133.48,82.04 133.48,82.59 133.37,82.7 133.37,82.99 133.39,83.04 133.39,83.04 133.44,83.15 133.44,83.28 133.37,83.43 133.37,83.64 133.39,83.69 133.44,83.78 133.44,83.79 133.44,83.98 133.43,84 133.43,84.38 133.44,84.39 133.44,84.63 133.24,84.84 U25.AU58
  BOTTOM w0.127: v4(123.77,32.48) 123.75,32.49 JDIM2.39
M_A_DQ22: length 64.9
  IN2 w0.14: v4(127.04,29.08) 127.35,29.08 127.48,29.21 127.48,29.46 127.02,29.92 127.02,37.72 125.09,39.65 125.09,46.81 125.47,47.18 125.47,47.9 125.35,48.03 124.99,48.03 124.86,48.15 124.86,48.32 124.99,48.44 125.35,48.44 125.47,48.57 125.47,51.39 125.12,51.74 125.12,52.07 126.12,53.07 126.12,58.87 126.28,59.03 126.28,72.06 131.01,76.8 131.01,77.4 132.12,78.5 v2(132.12,79.16)
  BOTTOM w0.076: U25.AV56 133.72,83.84 133.58,83.71 133.56,83.65 133.54,83.6 133.54,83.47 133.54,83.45 133.58,83.37 133.61,83.31 133.61,83.08 133.58,83.06 133.54,82.95 133.54,82.76 133.64,82.66 133.64,81.53 132.59,80.48 132.59,80.19
  BOTTOM w0.127: JDIM2.52 127.65,28.88 127.45,29.08 v4(127.04,29.08) ; v2(132.12,79.16) 132.14,79.16 132.59,79.6 132.59,80.19
M_A_DQ23: length 66.7
  IN2 w0.14: v4(127.93,30.68) 127.93,30.28 128.08,30.12 128.4,30.12 128.55,30.28 128.55,34.98 128.15,35.38 128.15,38.05 126.16,40.03 126.16,46.42 126.56,46.82 126.56,47.34 127.31,48.08 127.31,69.94 127.43,70.06 127.89,70.06 128.01,70.18 128.01,70.36 127.89,70.48 127.75,70.48 127.63,70.6 127.63,70.78 127.75,70.9 129.63,70.9 129.84,71.11 129.84,74.17 131.74,76.07 v2(132.05,76.07)
  BOTTOM w0.076: 133.5,80.19 133.5,80.69 134.14,81.33 134.14,82.55 134.28,82.7 134.28,83.19 134.12,83.35 134.12,83.66 134.01,83.77 134.01,84.06 134.01,84.07 134.01,84.31 133.72,84.6 U25.AU56
  BOTTOM w0.127: v4(127.93,30.68) 127.93,30.7 128.53,31.29 128.53,32.51 127.95,33.08 JDIM2.53 ; v2(132.05,76.07) 132.79,76.07 133.48,76.76 133.48,78.92 133.5,78.94 133.5,80.19
M_A_DQ24: length 64.1
  IN2 w0.14: v4(129.76,30.7) 130.11,30.7 130.25,30.84 130.25,32.46 129.78,32.93 129.78,38.12 127.77,40.13 127.77,46.84 128.51,47.58 128.51,61.81 128.63,61.93 129.18,61.93 129.31,62.05 129.31,62.22 129.18,62.35 128.64,62.35 128.51,62.47 128.51,62.64 128.64,62.77 129.36,62.77 129.48,62.89 129.48,63.06 129.36,63.19 128.64,63.19 128.51,63.31 128.51,63.48 128.64,63.6 129.19,63.6 129.3,63.72 129.3,68.78 131.05,70.53 131.05,73.46 133.75,76.16 133.75,77.71 v2(134.06,78.02)
  BOTTOM w0.076: 134.85,80.19 134.85,80.65 134.63,80.87 134.63,82.34 134.78,82.49 134.78,82.76 U25.AY54
  BOTTOM w0.127: JDIM2.57 129.15,31.31 v4(129.76,30.7) ; v2(134.06,78.02) 134.51,78.02 134.85,78.36 134.85,80.19
M_A_DQ25: length 65
  IN2 w0.14: v4(129.8,32.27) 129.78,32.27 129.44,32.61 129.44,37.98 127.42,39.99 127.42,46.98 128.17,47.72 128.17,63.94 128.29,64.06 128.83,64.06 128.96,64.18 128.96,64.36 128.83,64.48 128.29,64.48 128.17,64.6 128.17,64.78 128.29,64.9 128.77,64.9 128.89,65.02 128.89,65.2 128.77,65.32 128.29,65.32 128.17,65.44 128.17,65.61 128.29,65.74 128.79,65.74 128.92,65.86 128.92,66.03 128.79,66.16 128.29,66.16 128.17,66.28 128.17,66.45 128.29,66.58 128.79,66.58 128.92,66.7 128.92,66.87 128.79,66.99 128.29,66.99 128.17,67.12 128.17,67.29 128.29,67.41 128.8,67.41 128.93,67.55 128.93,67.68 128.78,67.83 128.34,67.83 128.22,67.96 128.22,68.13 128.34,68.25 128.65,68.25 128.8,68.4 128.8,68.77 130.71,70.67 130.71,73.6 133.41,76.3 133.41,79.3 133.57,79.46 133.89,79.46 v2(134.06,79.29)
  BOTTOM w0.076: 134.52,80.19 134.47,80.24 134.47,82.41 134.61,82.56 134.61,83.01 134.91,83.3 U25.AW54
  BOTTOM w0.127: JDIM2.59 129.75,32.97 129.9,32.82 130.17,32.82 130.33,32.66 130.33,32.43 130.17,32.27 v4(129.8,32.27) ; v2(134.06,79.29) 134.23,79.29 134.52,79.58 134.52,80.19
M_A_DQ26: length 64.3
  IN2 w0.14: v4(133.48,28.59) 133.48,29.28 133.48,29.28 133.48,29.53 132.34,30.67 132.34,38.38 130.51,40.21 130.51,43.88 130.88,44.25 130.88,46.57 130.63,46.82 130.63,56.25 130.76,56.38 131.3,56.38 131.43,56.5 131.43,56.67 131.3,56.79 130.76,56.79 130.63,56.92 130.63,57.09 130.76,57.21 131.38,57.21 131.5,57.34 131.5,57.51 131.38,57.63 130.83,57.63 130.71,57.76 130.71,57.93 130.83,58.05 131.38,58.05 131.5,58.17 131.5,58.68 131.88,59.06 131.88,67.67 133.05,68.83 133.05,72.62 136.2,75.78 136.2,80.67 136.41,80.87 v2(136.7,80.87)
  BOTTOM w0.076: v2(136.7,80.87) 136.45,81.12 136.45,82.39 136.39,82.46 136.39,82.73 136.38,82.73 136.38,82.76 U25.AY52
  BOTTOM w0.127: v4(133.48,28.59) 133.05,28.16 JDIM2.70
M_A_DQ27: length 65.7
  IN2 w0.14: v2(136.7,79.57) 137.16,79.11 137.16,75.76 133.77,72.37 133.77,67.93 132.74,66.91 132.74,58.95 132.21,58.42 132.21,51.38 132.09,51.26 131.55,51.26 131.43,51.14 131.43,50.96 131.55,50.84 132.31,50.84 132.43,50.72 132.43,50.54 132.31,50.42 131.55,50.42 131.43,50.3 131.43,50.12 131.55,50 132.31,50 132.43,49.88 132.43,49.7 132.31,49.58 131.85,49.58 131.6,49.33 131.6,48.45 131.72,48.32 132.31,48.32 132.43,48.2 132.43,48.03 132.31,47.9 131.83,47.9 131.71,47.78 131.71,47.61 132.19,47.13 132.19,46.7 131.77,46.29 131.77,44.47 132.13,44.11 132.13,39.56 133.1,38.59 133.1,32.66 133.3,32.46 133.3,31.25 v4(132.85,30.8)
  BOTTOM w0.076: U25.AW52 136.48,83.32 136.48,83.11 136.5,83.06 136.5,83.05 136.55,82.95 136.55,82.52 136.72,82.36 136.72,81.42 137.13,81 137.13,79.98 137.08,79.93 137.06,79.93
  BOTTOM w0.127: 137.06,79.93 136.7,79.58 v2(136.7,79.57) ; JDIM2.69 132.75,33.09 133.3,32.54 133.3,31.34 132.85,30.88 v4(132.85,30.8)
M_A_DQ28: length 65.7
  IN2 w0.14: v2(134.06,80.56) 133.22,80.56 133.06,80.41 133.06,76.48 130.37,73.78 130.37,70.81 129.89,70.34 128.65,70.34 128.53,70.22 128.53,70.04 128.65,69.92 128.8,69.92 128.92,69.8 128.92,69.62 128.8,69.5 127.95,69.5 127.83,69.38 127.83,69.21 127.95,69.08 128.34,69.08 128.46,68.96 128.46,68.79 128.34,68.66 127.95,68.66 127.83,68.54 127.83,47.87 127.08,47.12 127.08,39.85 129.08,37.85 129.08,32.48 129.31,32.26 129.31,29.35 v4(129.41,29.25)
  BOTTOM w0.076: v2(134.06,80.56) 134.3,80.81 134.3,82.48 134.45,82.63 134.45,83.11 134.61,83.27 134.61,83.79 U25.AV54
  BOTTOM w0.127: v4(129.41,29.25) 128.85,28.7 JDIM2.56
M_A_DQ29: length 66.6
  IN2 w0.14: v4(129.45,27.76) 130.14,27.07 131.11,27.07 132.08,28.04 132.08,29.96 131.58,30.46 131.58,38.17 129.49,40.27 129.49,46.52 129.95,46.98 129.95,60.39 130.98,61.42 130.98,68.29 132.36,69.67 132.36,72.92 135,75.56 135,77.27 135.18,77.44 135.18,78.76 v2(135.7,79.28)
  BOTTOM w0.076: U25.AU54 135.67,84.84 135.87,84.63 135.87,83.79 135.87,83.78 135.82,83.69 135.8,83.64 135.8,83.43 135.87,83.28 135.87,83.15 135.83,83.04 135.8,82.99 135.8,82.51 136.1,82.21 136.1,80.73 135.7,80.32 135.7,80.19
  BOTTOM w0.127: 135.7,80.19 v2(135.7,79.28) ; JDIM2.58 v4(129.45,27.76)
M_A_DQ30: length 65.8
  IN2 w0.14: v4(135.7,77.91) 135.7,77.48 135.25,77.04 135.25,75.33 132.7,72.77 132.7,69.27 131.43,68.01 131.43,60.34 131.28,60.19 130.41,60.19 130.29,60.07 130.29,59.9 130.41,59.78 131.37,59.78 131.49,59.65 131.49,59.48 131.37,59.36 130.41,59.36 130.29,59.23 130.29,46.84 129.83,46.38 129.83,44.11 130.07,43.87 130.07,43.22 129.83,42.98 129.83,42.08 130.07,41.83 130.07,41.31 129.83,41.07 129.83,40.41 131.96,38.28 131.96,30.57 132.48,30.04 132.48,28.88 132.99,28.37 132.99,27.99 132.78,27.78 v2(132.45,27.78)
  BOTTOM w0.076: U25.AV52 136.15,83.84 136.02,83.71 135.99,83.65 135.97,83.6 135.97,83.47 135.97,83.45 136.01,83.37 136.04,83.31 136.04,83.11 136.02,83.06 135.97,82.95 135.97,82.58 136.27,82.28 136.27,80.29 136.2,80.22 136.2,80.19
  BOTTOM w0.127: v4(135.7,77.91) 136.2,78.41 136.2,80.19 ; JDIM2.68 v2(132.45,27.78)
M_A_DQ31: length 66.6
  IN2 w0.14: v4(132.85,32.27) 132.72,32.4 132.72,38.49 131.79,39.42 131.79,43.93 131.23,44.49 131.23,46.92 130.98,47.17 130.98,51.21 131.49,51.72 131.74,51.72 131.87,51.84 131.87,52.02 131.74,52.14 131.1,52.14 130.98,52.26 130.98,52.43 131.1,52.56 131.74,52.56 131.87,52.68 131.87,52.85 131.74,52.98 131.1,52.98 130.98,53.1 130.98,53.27 131.1,53.4 131.74,53.4 131.87,53.52 131.87,53.69 131.74,53.81 131.1,53.81 130.98,53.94 130.98,54.11 131.1,54.23 131.74,54.23 131.87,54.36 131.87,54.53 131.74,54.65 131.1,54.65 130.98,54.78 130.98,54.95 131.1,55.07 131.74,55.07 131.87,55.19 131.87,55.37 131.74,55.49 131.1,55.49 130.98,55.61 130.98,55.79 131.1,55.91 131.74,55.91 131.87,56.03 131.87,58.56 132.23,58.92 132.23,67.19 133.39,68.35 133.39,72.48 136.7,75.79 v2(136.7,78.28)
  BOTTOM w0.076: U25.AU52 136.64,84.45 136.64,83.15 136.69,83.04 136.72,82.99 136.72,82.59 136.96,82.35 136.96,81.43 137.33,81.06 137.33,80.33 137.47,80.19
  BOTTOM w0.127: 137.47,80.19 137.51,80.14 137.51,79.1 v2(136.7,78.28) ; JDIM2.67 132.15,32.48 132.36,32.27 v4(132.85,32.27)
M_A_DQ32: length 63.6
  IN2 w0.089: v2(149.59,78.86) 149.38,78.64 149.38,77.94 149.84,77.48 150.17,77.15 150.17,74.84 153.38,71.63 153.38,71.38
  IN2 w0.14: 153.38,71.38 153.38,65.37 154.79,63.97 154.79,51.9 155.18,51.51 155.18,46.9 154.5,46.23 154.5,43.16 154.65,43.02 154.65,38.85 154.42,38.62 154.42,33.24 153.85,32.67 153.85,29.92 153.6,29.67 153.6,26.66 153.73,26.53 153.92,26.53 154.05,26.66 v4(154.05,27.78)
  BOTTOM w0.076: U25.AY31 149.14,82.85 148.83,82.53 148.83,80.9 148.88,80.84 149.03,80.7 149.03,79.93
  BOTTOM w0.127: v4(154.05,27.78) 154.05,27.61 153.45,27.01 JDIM2.130 ; v2(149.59,78.86) 149.03,79.43 149.03,79.93
M_A_DQ33: length 64.7
  IN2 w0.089: 152.96,71.54 152.96,71.8 149.99,74.76 149.99,76.36 149.86,76.49 v2(149.59,76.49)
  IN2 w0.14: v4(153.37,32.4) 153.35,32.4 153.2,32.55 153.2,33.22 153.35,33.37 153.95,33.37 154.07,33.5 154.07,33.67 153.95,33.79 153.16,33.79 153.04,33.91 153.04,34.09 153.16,34.21 153.95,34.21 154.07,34.33 154.07,34.51 153.95,34.63 153.16,34.63 153.04,34.75 153.04,34.93 153.16,35.05 153.95,35.05 154.07,35.17 154.07,35.35 153.95,35.47 153.57,35.47 153.42,35.62 153.42,38.13 154.3,39.01 154.3,42.87 154.16,43.02 154.16,46.97 154.31,47.12 154.72,47.12 154.84,47.23 154.84,47.41 154.71,47.54 154.38,47.54 154.26,47.66 154.26,47.83 154.38,47.96 154.71,47.96 154.84,48.08 154.84,48.25 154.71,48.38 154.38,48.38 154.26,48.5 154.26,48.67 154.38,48.79 154.71,48.79 154.84,48.92 154.84,51.37 154.44,51.76 154.44,63.82 152.96,65.31 152.96,71.54
  BOTTOM w0.076: 148.64,79.93 148.64,82.57 148.94,83.13 149.14,83.33 U25.AW31
  BOTTOM w0.127: v2(149.59,76.49) 150.05,76.95 150.05,77.77 148.64,79.18 148.64,79.93 ; JDIM2.131 153.75,33.01 154.07,32.69 154.07,32.44 153.95,32.31 153.46,32.31 v4(153.37,32.4)
M_A_DQ34: length 63.6
  IN2 w0.089: v2(150.81,79.92) 151.41,79.31 151.41,77.33 151.27,77.18 151.27,75.34 152.71,73.9 152.88,73.9 152.91,73.87
  IN2 w0.14: 152.91,73.87 152.92,73.87 156.08,70.71 156.08,66.19 157.7,64.56 157.7,58.05 157.83,57.93 158,57.93 158.14,57.78 158.14,57.63 158.02,57.51 157.71,57.51 157.59,57.38 157.59,57.21 157.71,57.09 158.02,57.09 158.14,56.97 158.14,56.79 158.02,56.67 157.71,56.67 157.59,56.55 157.59,56.37 157.71,56.25 158.02,56.25 158.14,56.13 158.14,55.95 158.02,55.83 157.71,55.83 157.59,55.71 157.59,55.53 157.71,55.41 158.02,55.41 158.14,55.29 158.14,55.12 158.02,54.99 157.71,54.99 157.59,54.87 157.59,54.7 157.71,54.57 158.02,54.57 158.14,54.45 158.14,49.03 157.68,48.57 157.68,46.81 157.71,46.79 157.71,43.41 157.36,43.07 157.36,40.63 157.18,40.44 157.18,33 156.85,32.67 156.85,31.13 156.98,31 v4(157.48,31)
  BOTTOM w0.076: v2(150.81,79.92) 150.37,80.36 150.37,82.77 U25.AY29
  BOTTOM w0.127: v4(157.48,31) 157.16,31 156.75,31.41 JDIM2.141
M_A_DQ35: length 64.7
  IN2 w0.089: 152.93,74.16 152.73,74.16 151.45,75.44 151.45,77.06 152.04,77.65 152.04,78.54 151.79,78.79 151.79,80.19 151.42,80.55 v2(150.81,80.55)
  IN2 w0.14: 152.93,74.16 153.03,74.16 156.42,70.77 156.42,66.33 158.17,64.58 158.17,62.53 158.27,62.42 158.58,62.42 158.7,62.3 158.7,62.13 158.58,62 158.28,62 158.15,61.88 158.15,61.71 158.28,61.59 158.58,61.59 158.7,61.46 158.7,61.29 158.58,61.17 158.28,61.17 158.15,61.04 158.15,60.87 158.28,60.75 158.58,60.75 158.7,60.62 158.7,60.45 158.58,60.33 158.28,60.33 158.15,60.21 158.15,60.03 158.28,59.91 158.58,59.91 158.7,59.79 158.7,59.61 158.58,59.49 158.27,59.49 158.15,59.37 158.15,59.19 158.27,59.07 158.58,59.07 158.7,58.95 158.7,58.77 158.58,58.65 158.27,58.65 158.15,58.53 158.15,58.36 158.27,58.23 158.36,58.23 158.49,58.11 158.49,48.89 158.03,48.43 158.03,48.1 158.15,47.98 158.37,47.98 158.49,47.86 158.49,47.68 158.37,47.56 158.15,47.56 158.03,47.44 158.03,47.27 158.15,47.14 158.42,47.14 158.54,47.02 158.54,46.85 158.42,46.72 158.2,46.72 158.05,46.57 158.05,43.27 157.71,42.92 157.71,40.48 157.52,40.3 157.52,39.96 157.64,39.83 157.9,39.83 158.02,39.71 158.02,39.54 157.9,39.41 157.64,39.41 157.52,39.29 157.52,39.12 157.64,39 157.96,39 158.09,38.87 158.09,38.7 157.96,38.58 157.64,38.58 157.52,38.45 157.52,32.69 v4(157.36,32.53)
  BOTTOM w0.076: U25.AW29 150.49,83.3 150.78,83.01 150.78,82.76 150.65,82.64 150.65,80.71 v2(150.81,80.55)
  BOTTOM w0.127: v4(157.36,32.53) 157.36,33.03 157.35,33.04 JDIM2.143
M_A_DQ36: length 65.5
  IN2 w0.089: v2(149.59,75.22) 149.59,74.91 152.56,71.94 152.56,71.55
  IN2 w0.14: 152.56,71.55 152.56,65.22 153.88,63.9 153.88,47.21 153.81,47.14 153.81,42.88 153.96,42.73 153.96,39.18 152.97,38.19 152.97,36.76 152.7,36.49 152.7,28.6 152.85,28.45 153.08,28.45 153.24,28.6 153.24,30.62 v4(153.37,30.75)
  BOTTOM w0.076: 148.26,79.93 148.26,82.19 148.66,82.97 148.68,83 148.7,83.04 148.75,83.14 ; U25.AV31 148.75,83.8 148.75,83.14 ; 148.75,83.14 148.75,83.14 148.75,83.14
  BOTTOM w0.127: v2(149.59,75.22) 149.15,75.66 149.15,78.21 148.26,79.09 148.26,79.93 ; v4(153.37,30.75) 152.86,31.26 152.86,32.64 153.15,32.93 JDIM2.129
M_A_DQ37: length 65.7
  IN2 w0.089: 153.72,71.35 153.72,71.58 150.35,74.95 150.35,77.24 149.88,77.7 149.88,78.56 149.99,78.67 149.99,79.14 v2(149.59,79.54)
  IN2 w0.14: v4(154.05,29.2) 154.56,28.69 154.75,28.69 154.93,28.87 154.93,29.16 154.19,29.91 154.19,32.52 154.76,33.1 154.76,38.46 154.99,38.68 154.99,43.16 154.85,43.3 154.85,46.07 155.52,46.75 155.52,51.65 155.35,51.82 155.35,63.89 153.72,65.52 153.72,71.35
  BOTTOM w0.076: 149.99,79.93 150.03,79.98 150.03,82.99 150.06,83.04 150.06,83.04 150.11,83.15 150.11,83.28 150.03,83.43 150.03,83.64 150.06,83.69 150.1,83.78 150.11,83.79 150.11,83.98 150.09,84 150.09,84.38 150.11,84.39 150.11,84.63 149.9,84.84 U25.AU31
  BOTTOM w0.127: 149.99,79.93 v2(149.59,79.54) ; v4(154.05,29.2) 154.39,29.2 154.84,28.75 154.84,27.89 154.05,27.1 JDIM2.132
M_A_DQ38: length 65
  IN2 w0.089: 155.2,70.78 155.2,70.89 150.9,75.19 150.9,77.44 150.51,77.83 150.51,78.19 150.79,78.47 v2(150.79,78.63)
  IN2 w0.14: v4(156.5,27.53) 156.5,26.2 156.38,26.08 156.1,26.08 156.01,26.18 156.01,29.13 156.16,29.29 156.16,33 156.49,33.33 156.49,40.72 156.68,40.91 156.68,43.35 157.02,43.69 157.02,46.5 156.96,46.57 156.96,48.99 156.84,49.11 156.84,64.44 155.2,66.07 155.2,70.78
  BOTTOM w0.076: U25.AV29 150.38,83.84 150.25,83.71 150.2,83.6 150.2,83.47 150.21,83.45 150.25,83.37 150.25,83.37 150.27,83.31 150.27,83.11 150.2,82.95 150.2,80.11 150.36,79.95 150.36,79.86
  BOTTOM w0.127: v4(156.5,27.53) 156.45,27.48 JDIM2.140 ; 150.36,79.86 150.36,79.06 v2(150.79,78.63)
M_A_DQ39: length 66.3
  IN2 w0.089: 152.94,73.52 152.83,73.63 152.71,73.63 151.08,75.27 151.08,77.83 v2(150.91,78)
  IN2 w0.14: v4(156.51,28.97) 156.51,32.84 156.84,33.17 156.84,40.58 157.02,40.77 157.02,43.21 157.36,43.55 157.36,46.65 157.34,46.67 157.34,48.71 157.8,49.17 157.8,51.55 157.68,51.67 157.3,51.67 157.18,51.79 157.18,51.97 157.3,52.09 157.68,52.09 157.8,52.21 157.8,52.39 157.68,52.51 157.3,52.51 157.18,52.63 157.18,52.8 157.3,52.93 157.68,52.93 157.8,53.05 157.8,53.22 157.68,53.35 157.3,53.35 157.18,53.47 157.18,53.64 157.3,53.77 157.68,53.77 157.8,53.89 157.8,54.06 157.68,54.18 157.39,54.18 157.25,54.33 157.25,57.69 157.36,57.8 157.36,64.4 155.74,66.02 155.74,70.73 152.94,73.52
  BOTTOM w0.076: 151.23,78.77 151.23,79.37 151.28,79.43 151.28,80.64 150.82,81.1 150.82,82.57 150.95,82.7 150.95,83.08 150.78,83.24 150.78,83.66 150.66,83.78 150.66,84.05 150.68,84.07 150.68,84.31 150.38,84.6 U25.AU29
  BOTTOM w0.127: v4(156.51,28.97) 157.05,28.43 JDIM2.142 ; v2(150.91,78) 151.23,78.32 151.23,78.77
M_A_DQ40: length 63.4
  IN2 w0.14: v2(152.84,74.74) 156.94,70.63 156.94,66.55 158.79,64.7 158.79,63.02 159.26,62.55 159.26,58.04 159.06,57.84 159.06,44.63 158.61,44.18 158.61,38.37 158.54,38.31 158.54,35.89 158.12,35.47 158.12,30.28 157.86,30.02 157.63,30.02 157.42,29.81 157.42,28.71 157.76,28.37 157.76,28.07 157.42,27.74 157.42,27.3 157.57,27.14 158.22,27.14 158.37,27.3 v4(158.37,27.7)
  BOTTOM w0.076: 151.92,79.17 151.78,79.31 151.78,80.84 151.33,81.29 151.33,82.38 151.57,82.62 U25.AY27
  BOTTOM w0.127: v2(152.84,74.74) 152.84,75.38 152.68,75.54 152.68,77.21 152.5,77.39 152.5,78.71 152.17,79.05 152.04,79.05 151.92,79.17 ; v4(158.37,27.7) 158.25,27.58 JDIM2.146
M_A_DQ41: length 64.8
  IN2 w0.089: 153.4,74.5 153.28,74.62 153.28,74.89 152.41,75.76 152.03,75.76 v2(151.88,75.6)
  IN2 w0.14: 153.4,74.5 157.29,70.62 157.29,66.69 159.14,64.84 159.14,63.16 159.61,62.69 159.61,56.51 159.41,56.31 159.41,55.88 159.61,55.68 159.61,55.17 159.41,54.97 159.41,54.53 159.61,54.34 159.61,53.9 159.41,53.7 159.41,53.26 159.61,53.07 159.61,52.63 159.41,52.43 159.41,51.99 159.61,51.8 159.61,51.36 159.41,51.16 159.41,50.67 159.61,50.47 159.61,50.05 159.41,49.85 159.41,44.49 158.95,44.03 158.95,38.24 158.89,38.17 158.89,35.75 158.5,35.36 158.5,30.13 157.76,29.4 157.76,29.07 157.9,28.94 158.08,28.94 v4(158.37,29.23)
  BOTTOM w0.076: 151.92,78.79 151.61,79.09 151.61,80.77 151.16,81.22 151.16,82.44 151.28,82.56 151.28,83.01 151.57,83.3 U25.AW27
  BOTTOM w0.127: v2(151.88,75.6) 152.3,76.02 152.3,77.05 152.12,77.23 152.12,78.59 151.92,78.79 ; JDIM2.148 158.85,28.75 v4(158.37,29.23)
M_A_DQ42: length 63.2
  IN2 w0.089: 156.44,73.68 156.43,73.7 156.1,73.7 153.67,76.12 153.67,77.15 153.83,77.3 153.83,78.24 v2(153.3,78.77)
  IN2 w0.14: v4(161.18,31.16) 161.39,31.16 161.66,31.43 161.66,38.26 162.14,38.73 162.14,47.16 162.29,47.31 162.29,50.86 162.85,51.42 162.85,60.62 162.73,60.75 162.41,60.75 162.29,60.87 162.29,61.04 162.41,61.17 162.73,61.17 162.85,61.29 162.85,61.46 162.73,61.59 162.41,61.59 162.29,61.71 162.29,61.88 162.41,62 162.73,62 162.85,62.13 162.85,62.3 162.73,62.42 162.41,62.42 162.29,62.55 162.29,62.72 162.41,62.84 162.73,62.84 162.85,62.97 162.85,63.14 162.73,63.26 162.41,63.26 162.29,63.38 162.29,64.99 159.64,67.64 159.64,70.48 156.44,73.68 156.44,73.68
  BOTTOM w0.076: U25.AY25 152.79,82.76 152.79,82.01 153,81.81 153,80.3 153.3,80
  BOTTOM w0.127: 153.3,80 v2(153.3,78.77) ; JDIM2.159 162.15,32.13 v4(161.18,31.16)
M_A_DQ43: length 64.2
  IN2 w0.089: v2(153.55,80.35) 153.63,80.35 154.09,79.89 154.09,77.04 153.85,76.8 153.85,76.21 156.13,73.93 156.52,73.93 156.53,73.92
  IN2 w0.14: 156.53,73.92 159.99,70.46 159.99,67.78 162.83,64.94 162.83,63.65 163.19,63.28 163.19,47.57 162.48,46.86 162.48,38.59 162.01,38.11 162.01,31.12 161.57,30.69 161.19,30.31 161.19,29.13 161.57,28.75 161.57,27.64 161.74,27.47 162.08,27.47 v4(162.18,27.58)
  BOTTOM w0.076: U25.AW25 153.14,83.32 153.14,83.11 153.16,83.06 153.17,83.05 153.21,82.95 153.21,82.76 152.96,82.51 152.96,82.08 153.16,81.88 153.16,80.74 v2(153.55,80.35)
  BOTTOM w0.127: JDIM2.160 162.45,27.31 v4(162.18,27.58)
M_A_DQ44: length 64.5
  IN2 w0.089: 153.52,74.76 153.52,74.9 152.61,75.82 152.61,76.07 151.85,76.82 v2(151.85,76.87)
  IN2 w0.14: 153.52,74.76 157.65,70.63 157.65,66.81 159.48,64.98 159.48,63.3 159.96,62.82 159.96,49.91 159.75,49.7 159.75,44.35 159.29,43.89 159.29,38.1 159.23,38.04 159.23,35.61 158.88,35.26 158.88,29.68 159.03,29.53 159.24,29.53 159.39,29.68 v4(159.39,31.36)
  BOTTOM w0.076: 151.45,78.79 151.45,80.71 150.98,81.17 150.98,82.5 151.11,82.63 151.11,83.08 151.28,83.25 151.28,83.66 151.68,84.06 U25.AV27
  BOTTOM w0.127: v2(151.85,76.87) 151.74,76.98 151.74,78.5 151.45,78.79 ; v4(159.39,31.36) 158.55,32.2 JDIM2.147
M_A_DQ45: length 65.3
  IN2 w0.089: 153.83,74.78 153.72,74.88 153.72,74.96 152.82,75.86 152.82,76.21 152.42,76.61 152.42,79.27 v2(152.21,79.49)
  IN2 w0.14: v4(159.39,32.78) 159.39,33.11 159.62,33.34 159.62,33.55 159.47,33.7 159.34,33.7 159.22,33.82 159.22,34 159.36,34.13 159.87,34.13 159.99,34.25 159.99,34.42 159.87,34.55 159.35,34.55 159.22,34.67 159.22,34.84 159.35,34.97 159.87,34.97 159.99,35.09 159.99,35.26 159.87,35.39 159.7,35.39 159.57,35.51 159.57,37.9 159.64,37.97 159.64,38.98 159.76,39.1 159.97,39.1 160.09,39.22 160.09,39.4 159.97,39.52 159.76,39.52 159.64,39.64 159.64,39.82 159.76,39.94 159.97,39.94 160.09,40.06 160.09,40.24 159.97,40.36 159.76,40.36 159.64,40.48 159.64,43.75 160.09,44.21 160.09,47.97 160.23,48.11 160.52,48.11 160.64,48.23 160.64,48.41 160.52,48.53 160.23,48.53 160.09,48.66 160.09,48.89 160.21,49 160.49,49 160.64,49.16 160.64,50.2 160.36,50.48 160.36,50.85 160.55,51.04 160.55,51.74 160.36,51.93 160.36,52.38 160.48,52.5 160.48,52.95 160.32,53.11 160.32,53.61 160.48,53.77 160.48,63.4 160.36,63.53 159.94,63.53 159.82,63.65 159.82,63.82 159.94,63.94 160.52,63.94 160.64,64.07 160.64,64.24 160.52,64.36 159.94,64.36 159.82,64.49 159.82,65.12 157.99,66.95 157.99,70.61 153.83,74.78
  BOTTOM w0.076: 152.66,79.94 152.66,81.67 152.46,81.87 152.46,82.99 152.54,83.15 152.54,83.28 152.46,83.43 152.46,83.64 152.49,83.69 152.53,83.78 152.54,83.79 152.54,84.63 152.33,84.84 U25.AU27
  BOTTOM w0.127: 152.66,79.94 v2(152.21,79.49) ; JDIM2.149 159.15,33.02 v4(159.39,32.78)
M_A_DQ46: length 64.9
  IN2 w0.089: v2(153.3,77.5) 153.5,77.31 153.5,76.02 156.06,73.46 156.34,73.46 156.55,73.26
  IN2 w0.14: v4(161.16,32.71) 161.32,32.87 161.32,38.4 161.8,38.87 161.8,39.55 161.67,39.68 161.52,39.68 161.4,39.8 161.4,39.97 161.52,40.1 161.67,40.1 161.8,40.22 161.8,47.3 161.95,47.46 161.95,51.45 162.07,51.57 162.27,51.57 162.39,51.7 162.39,51.87 162.27,51.99 162.07,51.99 161.95,52.11 161.95,52.29 162.07,52.41 162.27,52.41 162.39,52.53 162.39,52.71 162.27,52.83 162.07,52.83 161.95,52.95 161.95,53.13 162.07,53.25 162.27,53.25 162.39,53.37 162.39,53.55 162.27,53.67 162.07,53.67 161.95,53.79 161.95,53.96 162.07,54.09 162.27,54.09 162.39,54.21 162.39,54.38 162.27,54.51 162.07,54.51 161.95,54.63 161.95,54.8 162.07,54.93 162.27,54.93 162.39,55.05 162.39,55.22 162.27,55.34 162.07,55.34 161.95,55.47 161.95,55.64 162.07,55.76 162.27,55.76 162.39,55.89 162.39,56.06 162.27,56.18 162.07,56.18 161.95,56.31 161.95,56.48 162.07,56.6 162.27,56.6 162.39,56.72 162.39,56.9 162.27,57.02 162.07,57.02 161.95,57.14 161.95,57.32 162.07,57.44 162.27,57.44 162.39,57.56 162.39,57.74 162.27,57.86 162.07,57.86 161.95,57.98 161.95,58.16 162.07,58.28 162.27,58.28 162.39,58.4 162.39,58.57 162.27,58.7 162.07,58.7 161.95,58.82 161.95,58.99 162.07,59.12 162.27,59.12 162.39,59.24 162.39,59.41 162.27,59.54 162.07,59.54 161.95,59.66 161.95,59.83 162.07,59.95 162.27,59.95 162.39,60.08 162.39,60.25 162.27,60.37 162.07,60.37 161.95,60.5 161.95,64.85 159.3,67.49 159.3,70.5 156.55,73.26
  BOTTOM w0.076: 152.88,80.1 152.83,80.15 152.83,81.74 152.63,81.94 152.63,82.95 152.68,83.06 152.7,83.11 152.7,83.31 152.68,83.37 152.64,83.46 152.63,83.47 152.63,83.6 152.68,83.71 152.92,83.95 U25.AV25
  BOTTOM w0.127: 152.88,80.1 152.88,77.83 153.2,77.5 v2(153.3,77.5) ; JDIM2.157 161.55,33.1 v4(161.16,32.71)
M_A_DQ47: length 65.8
  IN2 w0.089: 156.64,74.13 156.18,74.13 154.03,76.28 154.03,76.7 154.27,76.95 154.27,79.99 153.95,80.31 153.95,81.22 v2(153.55,81.62)
  IN2 w0.14: v4(162.2,29.1) 162.41,29.31 162.41,29.88 162.28,30.01 162.04,30.01 161.91,30.13 161.91,30.3 162.04,30.42 162.28,30.42 162.41,30.55 162.41,38.03 162.82,38.45 162.82,46.71 163.54,47.43 163.54,63.42 163.17,63.79 163.17,65.08 160.33,67.92 160.33,70.44 156.64,74.13
  BOTTOM w0.076: U25.AU25 153.3,84.45 153.3,83.15 153.35,83.04 153.38,82.99 153.38,82.69 153.24,82.55 153.13,82.44 153.13,82.14 153.55,81.72 v2(153.55,81.62)
  BOTTOM w0.127: JDIM2.158 161.85,27.27 161.67,27.45 161.67,29.11 161.82,29.26 162.04,29.26 v4(162.2,29.1)
M_A_DQ48: length 65.4
  IN2 w0.089: v2(156.32,74.56) 156.57,74.56 157.05,74.08
  IN2 w0.14: v4(163.58,29.23) 163.58,28.91 163.43,28.76 163.12,28.76 162.96,28.91 162.96,32.61 163.31,32.96 163.31,34.72 163.09,34.94 163.09,35.48 163.31,35.7 163.31,38.19 163.34,38.23 163.34,46.5 164.06,47.21 164.06,54.79 164.18,54.91 164.61,54.91 164.73,55.03 164.73,55.21 164.61,55.33 164.18,55.33 164.06,55.45 164.06,55.63 164.18,55.75 164.61,55.75 164.73,55.87 164.73,56.05 164.61,56.17 164.18,56.17 164.06,56.29 164.06,63.91 163.88,64.08 163.88,65.11 161.13,67.86 160.85,68.14 160.85,70.28 157.05,74.08
  BOTTOM w0.076: 154.28,79.71 154.28,82.62 154.27,82.63 U25.AY23
  BOTTOM w0.127: JDIM2.166 164.25,28.56 v4(163.58,29.23) ; v2(156.32,74.56) 156.32,75.2 154.28,77.23 154.28,79.71
M_A_DQ49: length 66.5
  IN2 w0.089: 158.6,73.18 158.38,73.4 158.3,73.4 155.32,76.39 v2(154.52,76.39)
  IN2 w0.14: v4(163.49,31.01) 163.49,30.72 163.64,30.57 163.85,30.57 163.96,30.68 163.96,32.45 164.12,32.61 164.28,32.61 164.41,32.73 164.41,32.9 164.28,33.03 164.12,33.03 163.99,33.15 163.99,33.32 164.12,33.45 164.28,33.45 164.41,33.57 164.41,33.74 164.28,33.86 164.12,33.86 163.99,33.99 163.99,34.16 164.12,34.28 164.28,34.28 164.41,34.41 164.41,34.58 164.28,34.7 164.12,34.7 163.99,34.83 163.99,35 164.12,35.12 164.28,35.12 164.41,35.24 164.41,35.42 164.28,35.54 164.12,35.54 163.99,35.66 163.99,37.91 164.03,37.95 164.03,39.92 164.15,40.04 164.47,40.04 164.59,40.17 164.59,40.34 164.47,40.46 164.15,40.46 164.03,40.59 164.03,46.21 164.74,46.92 164.74,51.56 165.41,52.23 165.41,60.89 165.26,61.05 164.88,61.05 164.74,61.18 164.74,65.22 161.54,68.42 161.54,70.24 158.6,73.18
  BOTTOM w0.076: U25.AW23 154.27,83.33 154.07,83.13 153.98,82.96 153.98,82.69 154.12,82.55 154.12,79.93 154.03,79.85
  BOTTOM w0.127: JDIM2.163 163.35,33 163.03,32.68 163.03,31.46 v4(163.49,31.01) ; v2(154.52,76.39) 154.03,76.88 154.03,79.85
M_A_DQ50: length 65.4
  IN2 w0.089: v2(155.28,78.29) 155.28,78.22 156.37,77.12 156.46,77.12 157.12,76.46 157.39,76.46 163.87,69.98 163.87,69.77
  IN2 w0.14: 163.87,69.77 163.87,69.76 167.4,66.23 167.4,65.37 167.54,65.23 167.81,65.23 167.92,65.12 167.92,64.93 167.8,64.81 167.52,64.81 167.4,64.68 167.4,64.51 167.52,64.39 167.8,64.39 167.92,64.27 167.92,51.1 167.75,50.94 167.75,48.79 167.37,48.41 167.37,35.49 167.11,35.22 167.11,29.96 167.24,29.82 167.42,29.82 167.56,29.96 v4(167.56,31.23)
  BOTTOM w0.076: v2(155.28,78.29) 155.28,78.4 154.89,78.79 154.89,79.77 155.62,80.5 155.62,81.65 155.83,81.86 155.83,82.41 155.62,82.62 U25.AY21
  BOTTOM w0.127: v4(167.56,31.23) 166.95,31.84 JDIM2.175
M_A_DQ51: length 66.2
  IN2 w0.089: v2(155.28,79.59) 155.69,79.17 155.69,78.05 156.45,77.3 156.53,77.3 157.2,76.64 157.47,76.64 160.06,74.04 160.17,74.04
  IN2 w0.14: v4(167.58,32.78) 167.58,33.16 167.73,33.31 167.99,33.31 168.11,33.44 168.11,33.61 167.99,33.73 167.57,33.73 167.45,33.86 167.45,34.03 167.57,34.15 168.14,34.15 168.26,34.28 168.26,34.45 168.14,34.57 167.57,34.57 167.45,34.69 167.45,34.87 167.57,34.99 168.14,34.99 168.26,35.11 168.26,35.29 168.14,35.41 167.84,35.41 167.72,35.53 167.72,38.2 167.84,38.32 168.14,38.32 168.26,38.45 168.26,38.62 168.14,38.74 167.84,38.74 167.72,38.87 167.72,39.04 167.84,39.16 168.14,39.16 168.26,39.28 168.26,39.46 168.14,39.58 167.84,39.58 167.72,39.7 167.72,39.88 167.84,40 168.14,40 168.26,40.12 168.26,40.3 168.14,40.42 167.84,40.42 167.72,40.54 167.72,46.13 167.87,46.28 168.12,46.28 168.25,46.41 168.25,46.58 168.12,46.71 167.87,46.71 167.74,46.84 167.74,47.02 167.87,47.14 168.12,47.14 168.25,47.27 168.25,47.45 168.12,47.57 167.89,47.57 167.74,47.73 167.74,48.16 167.89,48.31 168.19,48.31 168.65,48.77 168.65,51.16 168.26,51.55 168.26,65.87 164.18,69.95 164.18,70.11 160.25,74.04 160.17,74.04
  BOTTOM w0.076: U25.AW21 155.62,83.3 155.64,83.28 155.92,83.01 155.92,82.56 156,82.48 156,81.79 155.79,81.58 155.79,80.43 155.28,79.93 v2(155.28,79.59)
  BOTTOM w0.127: v4(167.58,32.78) 167.55,32.81 JDIM2.177
M_A_DQ52: length 67.2
  IN2 w0.089: v2(155.41,75.48) 155.97,75.48 158.25,73.2 158.25,73.2
  IN2 w0.14: 158.25,73.2 161.19,70.26 161.19,68.28 161.27,68.2 161.27,68.2 164.4,65.07 164.4,60.82 164.52,60.7 164.95,60.7 165.07,60.58 165.07,60.41 164.95,60.28 164.52,60.28 164.4,60.16 164.4,59.99 164.52,59.86 164.95,59.86 165.07,59.74 165.07,59.57 164.95,59.44 164.52,59.44 164.4,59.32 164.4,59.15 164.52,59.03 164.95,59.03 165.07,58.9 165.07,58.73 164.95,58.61 164.52,58.61 164.4,58.48 164.4,58.31 164.52,58.19 164.95,58.19 165.07,58.06 165.07,57.89 164.95,57.77 164.52,57.77 164.4,57.65 164.4,57.47 164.52,57.35 164.95,57.35 165.07,57.23 165.07,57.05 164.95,56.93 164.52,56.93 164.4,56.81 164.4,56.63 164.52,56.51 164.95,56.51 165.07,56.39 165.07,54.53 164.95,54.41 164.62,54.41 164.49,54.28 164.49,54.1 164.62,53.98 164.92,53.98 165.05,53.85 165.05,53.67 164.92,53.54 164.62,53.54 164.49,53.42 164.49,53.24 164.62,53.11 164.92,53.11 165.07,52.96 165.07,52.38 164.4,51.7 164.4,47.07 163.69,46.36 163.69,38.09 163.65,38.05 163.65,32.66 v4(163.49,32.5)
  BOTTOM w0.076: U25.AV23 153.89,83.8 153.89,83.14 153.83,83.04 153.81,83 153.81,82.62 153.95,82.48 153.95,80.11 153.78,79.93 153.78,79.86
  BOTTOM w0.127: JDIM2.165 163.95,32.96 v4(163.49,32.5) ; 153.78,79.86 153.78,76.47 154.77,75.48 v2(155.41,75.48)
