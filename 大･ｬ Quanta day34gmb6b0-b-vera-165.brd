# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SATA-202407-2-13P-R
  round 1.194 hole 1.194 unplated: (-10.4,0) (10.4,0)
  round 1.067 hole 0.711: 1(9.38,1.75) 2(8.11,1.75) 3(6.84,1.75) 4(5.57,1.75) 5(4.3,1.75) 6(3.03,1.75) 7(1.76,1.75)
  round 1.016 hole 0.61: 8(-4.45,2.75) 9(-5.45,1.75) 10(-6.45,2.75) 11(-7.45,1.75) 12(-8.45,2.75) 13(-9.45,1.75)
  round 5.994 hole 2.311: 14(13.15,1) 15(-13.15,1)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SDCARD-PSDBTC-09GLBS1NN4H3-11P
  round 1.397 hole 1.397 unplated: (-12.5,-8.25) (12.5,8.25)
  rect 0.711x2.007 smd: 1(6.075,14.75) 2(3.575,14.75) 3(1.075,14.75) 4(-1.425,14.75) 5(-3.925,14.75) 6(-6.425,14.75) 7(-8.775,14.75) 8(-10.65,14.75) 9(8.575,14.75) 10(-12.7,14.75)
  rect 0.559x2.007 smd: 11(-13.75,14.75)
  oval 1.194x2.21 hole 0.61x1.6: 12(14.6,9.45) 13(-14.6,9.45) 14(14.6,-8.25) 15(-14.6,-8.25)
SHORT0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
SHORT0402
  rect 0.648x0.5 smd: 1(-0.39,0) 2(0.39,0)
SHORT0603
  rect 1.168x0.711 smd: 1(0.737,0) 2(-0.737,0)
SHORT0805
  rect 1.397x1.346 smd: 1(0.895,0) 2(-0.895,0)
SHORT-SOLDERJUMPER-3
  custom 0.508x0.508 smd: 1(-1.016,0)
  custom 0.381x0.381 smd: 2(1.016,0)
SO-8FL-5P
  rect 0.991x0.762 smd: 1(3.73,-1.905) 2(3.73,-0.635) 3(3.73,0.635) 4(3.73,1.905)
  custom 1.132x1.132 smd: 5(0,0)
SOIC8-8-1_27
  rect 0.533x1.6 smd: 1(1.905,3.8) 2(0.635,3.8) 3(-0.635,3.8) 4(-1.905,3.8) 5(-1.905,-3.8) 6(-0.635,-3.8) 7(0.635,-3.8) 8(1.905,-3.8)
SOLDERJUMPER-2
  custom 0.381x0.381 smd: 1(-1.016,0) 2(1.016,0)
SON14-3X2-4-15P
  custom 0.05x0.05 smd: 1(-1.2,-1.025) 2(-0.8,-1.025) 3(-0.4,-1.025) 4(0,-1.025) 5(0.4,-1.025) 6(0.8,-1.025) 7(1.2,-1.025) 8(1.2,1.025) 9(0.8,1.025) 10(0.4,1.025) 11(0,1.025) 12(-0.4,1.025) 13(-0.8,1.025) 14(-1.2,1.025)
  rect 2.489x0.889 smd: 15(0,0)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT323_213-2_1-1_3-3P
  rect 0.559x0.61 smd: 1(0.925,0.65) 2(0.925,-0.65) 3(-0.925,0)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
TO252_134-9_9-4_57-SMT
  rect 2.997x1.499 smd: 1(8.1,-2.286) 3(8.1,2.286)
  rect 5.613x6.248 smd: 4(0.6,0)
TP1250-P14_4
  round 0.305 smd: 1(0,0)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TQFN16-2X3-4-17P
  rect 0.889x0.203 smd: 1(-1.15,1.2) 2(-1.15,0.8) 3(-1.15,0.4) 4(-1.15,0) 5(-1.15,-0.4) 6(-1.15,-0.8) 7(-1.15,-1.2) 9(1.15,-1.2) 10(1.15,-0.8) 11(1.15,-0.4) 12(1.15,0) 13(1.15,0.4) 14(1.15,0.8) 15(1.15,1.2)
  rect 0.203x0.889 smd: 8(0,-1.65) 16(0,1.65)
  custom 0.225x0.225 smd: 17(0,0)
TQFN24-4X4-5-34P
  rect 0.305x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 13(1.25,2) 14(0.75,2) 15(0.25,2) 16(-0.25,2) 17(-0.75,2) 18(-1.25,2)
  rect 0.787x0.305 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.25) 11(2,0.75) 12(2,1.25) 19(-2,1.25) 20(-2,0.75) 21(-2,0.25) 22(-2,-0.25) 23(-2,-0.75) 24(-2,-1.25)
  rect 2.692x2.692 smd: 25(0,0)
  round 0.61 hole 0.305: 26(-1,-1) 27(0,-1) 28(1,-1) 29(1,0) 30(1,1) 31(0,1) 32(-1,1) 33(-1,0) 34(0,0)
TRF-9_6-1_27-16P
  rect 0.762x1.905 smd: 1(-4.445,-4.383) 2(-3.175,-4.383) 3(-1.905,-4.383) 4(-0.635,-4.383) 5(0.635,-4.383) 6(1.905,-4.383) 7(3.175,-4.383) 8(4.445,-4.383) 9(4.445,4.383) 10(3.175,4.383) 11(1.905,4.383) 12(0.635,4.383) 13(-0.635,4.383) 14(-1.905,4.383) 15(-3.175,4.383) 16(-4.445,4.383)
TSOP6-2_8-95
  rect 0.787x0.635 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
TSSOP28-6_4-65
  rect 0.279x1.499 smd: 1(-4.225,-3.038) 2(-3.575,-3.038) 3(-2.925,-3.038) 4(-2.275,-3.038) 5(-1.625,-3.038) 6(-0.975,-3.038) 7(-0.325,-3.038) 8(0.325,-3.038) 9(0.975,-3.038) 10(1.625,-3.038) 11(2.275,-3.038) 12(2.925,-3.038) 13(3.575,-3.038) 14(4.225,-3.038) 15(4.225,3.038) 16(3.575,3.038) 17(2.925,3.038) 18(2.275,3.038) 19(1.625,3.038) 20(0.975,3.038) 21(0.325,3.038) 22(-0.325,3.038) 23(-0.975,3.038) 24(-1.625,3.038) 25(-2.275,3.038) 26(-2.925,3.038) 27(-3.575,3.038) 28(-4.225,3.038)
TSSOP28-6_4-65-29P-1_2H
  rect 0.254x1.549 smd: 1(-4.225,-2.8) 2(-3.575,-2.8) 3(-2.925,-2.8) 4(-2.275,-2.8) 5(-1.625,-2.8) 6(-0.975,-2.8) 7(-0.325,-2.8) 8(0.325,-2.8) 9(0.975,-2.8) 10(1.625,-2.8) 11(2.275,-2.8) 12(2.925,-2.8) 13(3.575,-2.8) 14(4.225,-2.8) 15(4.225,2.8) 16(3.575,2.8) 17(2.925,2.8) 18(2.275,2.8) 19(1.625,2.8) 20(0.975,2.8) 21(0.325,2.8) 22(-0.325,2.8) 23(-0.975,2.8) 24(-1.625,2.8) 25(-2.275,2.8) 26(-2.925,2.8) 27(-3.575,2.8) 28(-4.225,2.8)
  rect 6.452x2.362 smd: 29(0,0)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
USB-YUSB0015-P002A-9P
  round 0.991 hole 0.711: 1(3.5,9.47) 2(1,9.47) 3(-1,9.47) 4(-3.5,9.47) 5(-4,7.97) 6(-2,7.97) 7(0,7.97) 8(2,7.97) 9(4,7.97)
  oval 1.397x3.2 hole 0.787x2.591: 10(7.15,8.6) 11(-7.15,8.6)
  oval 1.397x2.489 hole 0.787x1.905: 12(-7.85,0) 13(7.85,0)
VQFN14-3_5X3_5-5-15P
  rect 0.838x0.279 smd: 1(-1.725,-0.75) 7(1.725,-0.75) 8(1.725,0.75) 14(-1.725,0.75)
  rect 0.279x0.838 smd: 2(-1,-1.725) 3(-0.5,-1.725) 4(0,-1.725) 5(0.5,-1.725) 6(1,-1.725) 9(1,1.725) 10(0.5,1.725) 11(0,1.725) 12(-0.5,1.725) 13(-1,1.725)
  rect 2.057x2.057 smd: 15(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1.05VMOD_OND: PC37.1 PQ5.3 PQ10.4 PR56.1 PR57.2
1.05VMOD_ONG: PQ5.2 PQ6.3 PQ9.2 PR52.2 PR55.1
5V_HSMBCK: D3.1 R196.1
5V_HSMBDT: D5.1 R202.1
5VS5_ON: PR184.2 U11.128
8008VFB1.5V: PR105.2 PR108.2 PU4.6
81101VCC: PC61.2 PR97.1 PU3.28
81101VRMP: PC174.1 PR74.1 PU3.7
81101VSN: PC59.2 PR96.1 PU3.26
81101VSP: PC60.2 PR101.1 PU3.27
+0.65V_DDR_VTT: C423.1 C425.1 C430.1 C431.1 C465.1 C466.1 C484.1 C490.1 C494.1 C495.1 EC32.1 EC38.1 JDIM1.203 JDIM1.204 JDIM2.203 JDIM2.204 PC98.1 PU7.2 PU7.20
+1.05V: C273.2 C274.1 C281.2 C288.1 C293.2 C294.1 C303.1 C304.1 C305.1 C306.1 C310.1 C322.1 C325.1 C330.1 C361.1 C380.2 C735.1 CN8.9 CN8.52 L16.2 L46.2 PC34.1 PC35.1 PC57.2 PJP1.2 PL1.2 PQ10.5 PQ10.6 PQ10.7 PQ10.8 PR78.1 PR81.1 PR83.1 PR87.1 R184.2 R210.2 R229.2 R264.1 R496.1 R506.1 R509.1 R521.1 R522.2 R533.1 R556.2 R557.2 U9.3 U25.AA21 U25.AC22 U25.AE8 U25.AE9 U25.AE22 U25.AE23 U25.AF9 U25.AF22 U25.AG8 U25.AG13 U25.AG14 U25.AG16 U25.AG17 U25.H11 U25.H15 U25.J11 U25.J17 U25.N8 U25.P9 U25.R21 U25.T21 U25.W21
+1.5V: C400.1 C403.1 C405.1 C647.1 C651.1 C652.1 CN22.6 CN22.28 CN22.48 CN26.6 CN26.28 CN26.48 L32.1 PC64.1 PC65.2 PL2.2 PR109.1 R171.2 R408.2 U25.J15
+1.05V_LAN: C228.1 C231.1 C232.1 C233.1 C234.1 C250.1 C259.1 C263.1 C264.1 C265.1 L15.2 R151.2 U8.3 U8.8 U8.22 U8.30
+1.05V_LAN_REGOUT: C266.1 L15.1 R151.1 U8.24
+1.05V_MODPHY: C235.2 C243.2 C257.2 L44.1 L45.1 PC38.1 PC39.1 PL1.1 PQ10.1 PQ10.2 PQ10.3 PR61.1 U25.K9 U25.L10 U25.M9
+1.05V_S2: PC175.1 PC176.1 PC177.1 PC178.1 PC179.1 PC186.1 PJP1.1 PL16.2 PR170.2
+1.05VS5: R201.1 R210.1 R547.1 R548.1 R554.1
+1.35VSUS: C351.2 C359.2 C398.1 C409.2 C412.1 C413.1 C414.1 C415.1 C416.1 C418.1 C419.1 C447.1 C448.1 C449.1 C450.1 C452.1 C453.1 C454.1 C474.1 C475.1 C476.1 C477.1 C478.1 C479.1 C480.1 C501.1 C502.1 C503.1 C504.1 C505.1 C506.1 C507.1 C508.1 C531.1 C532.1 C736.1 C737.1 C738.1 C739.1 C740.1 C742.1 C743.1 C744.1 C745.1 C746.1 EC31.1 EC33.1 EC34.1 EC35.1 EC36.1 EC39.1 EC40.1 EC43.1 EC46.1 EC47.1 EC48.1 EC51.1 EC52.1 EC53.1 JDIM1.75 JDIM1.76 JDIM1.81 JDIM1.82 JDIM1.87 JDIM1.88 JDIM1.93 JDIM1.94 JDIM1.99 JDIM1.100 JDIM1.105 JDIM1.106 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM2.75 JDIM2.76 JDIM2.81 JDIM2.82 JDIM2.87 JDIM2.88 JDIM2.93 JDIM2.94 JDIM2.99 JDIM2.100 JDIM2.105 JDIM2.106 JDIM2.111 JDIM2.112 JDIM2.117 JDIM2.118 JDIM2.123 JDIM2.124 PC93.1 PJP2.2 PU7.19 Q24.3 R266.2 R319.1 R352.1 R379.1 U25.AH26 U25.AJ31 U25.AJ33 U25.AJ37 U25.AN33 U25.AP43 U25.AR48 U25.AY35 U25.AY40 U25.AY44 U25.AY50
+1.35VSUS_S: PC75.1 PC76.1 PC201.1 PC208.1 PC215.1 PC230.1 PJP2.1 PL22.2 PR189.2
+3.3VS5_S: PC218.1 PC225.1 PC226.1 PC227.1 PC228.1 PC229.2 PJP4.1 PL21.2 PR188.2
+3V: C37.2 C125.2 C175.1 C282.2 C350.1 C372.2 C378.2 C392.1 C393.1 C399.1 C402.1 C404.1 C408.1 C437.1 C444.1 C463.2 C510.1 C511.1 C521.1 C523.2 C524.2 C530.1 C554.2 C557.2 C570.1 C573.1 C576.1 C8776.1 C8781.2 C8784.2 CN12.6 CN13.1 CN13.6 CN14.17 CN26.2 CN26.24 CN26.39 CN26.41 CN26.52 CN31.4 EC22.2 EC37.2 EC42.2 EC45.2 JDIM1.199 JDIM2.199 L33.1 L37.1 PR77.2 PR125.2 Q10.2 Q12.2 Q12.5 Q14.2 Q14.5 Q27.2 Q27.5 Q38.2 Q38.5 Q40.2 R1.1 R40.1 R58.1 R139.2 R144.1 R158.2 R170.2 R179.2 R181.1 R185.1 R187.1 R188.1 R189.2 R191.1 R194.1 R197.1 R203.1 R216.1 R260.1 R263.2 R268.2 R269.2 R273.1 R278.2 R285.1 R321.2 R334.1 R342.1 R344.1 R376.1 R386.2 R392.2 R406.2 R482.2 R486.2 R493.2 R499.2 R510.2 R511.2 R512.2 R513.2 R514.2 R515.2 R516.2 R518.2 R519.2 R520.2 R523.2 R524.2 R525.2 R526.1 R527.2 R528.2 R529.2 R530.2 R534.2 R535.2 R536.2 R538.2 R544.2 R546.2 R550.2 R551.2 R552.2 R602.2 R603.2 R613.1 R627.1 R7467.1 R8512.2 R8513.2 R8514.2 R8516.2 R8517.2 R8518.2 R8519.2 R8520.2 R8521.2 R8554.1 RP2.5 RP2.10 RP5.5 RP5.10 RP6.5 RP6.10 U2.4 U2.5 U11.11 U12.14 U16.1 U18.5 U18.10 U18.19 U18.24 U19.11 U19.27 U25.K14 U25.K16 U25.T9 U25.U8 U25.V8 U25.W9 U8021.1 U8021.13
+3V_AON: C352.1 U9.11
+3V_DEEP_SUS: C301.2 C373.1 C374.2 C726.2 CN9.1 CN9.3 R163.2 R164.2 R172.2 R180.2 R183.2 R186.2 R192.1 R195.2 R198.2 R199.2 R211.2 R218.2 R238.1 R255.2 R278.1 R282.2 R290.2 R503.2 R539.2 R540.2 R541.2 R549.2 R559.2 R560.1 R561.2 R565.2 R566.1 R567.2 R568.1 R569.1 R570.1 R571.2 R572.1 R574.1 R588.2 R8560.2 U25.AA9 U25.AC9 U25.AE20 U25.AE21 U25.AH11 U25.Y8 U26.1
+3V_DVDD: C578.1 C581.1 L37.2 R421.2 U20.9
+3V_DVDD-IO: C560.1 C564.1 L32.2 L33.2 U20.3
+3V_ECACC: C363.1 C366.2 L18.1 U11.74
+3V_RTC: C344.2 C364.1 C368.1 C371.1 C388.1 D9.3 R256.1 R277.1 R575.1 R576.2 R577.1 U9.14 U25.AG10
+3V_RTC_0: CN27.1 R252.1 R302.1
+3V_RTC_1: D9.1 R302.2
+3V_RTC_R: C347.1 R252.2 U9.10
+3V_S2: PC101.1 PC103.1 PR125.1 PU8.13 PU8.14
+3V_VSTBY: C334.2 L17.1 U11.127
+3V_WLAN_P: C105.1 C106.1 C109.1 C649.1 C650.1 CN22.2 CN22.24 CN22.39 CN22.41 CN22.52 Q4.2 Q5.2 Q17.3 R74.2 R95.2 R96.2 R308.1 R458.1
+3VCARD: C518.2 C536.1 C537.1 CN15.4 U19.12
+3VLANVCC: C227.1 C236.1 C237.1 C247.1 C248.1 C258.1 C260.1 C323.1 C338.1 PR133.1 R21.1 R444.1 U8.11 U8.23 U8.32 U9.2 U9.8
+3VLANVCC_S2: PC116.1 PC117.1 PR133.2 PU8.8 PU8.9
+3VLCD_CON: C10.2 C12.2 C48.1 C49.1 C52.1 CN2.27 CN2.28 L8.1
+3VPCU: C69.2 C329.1 C332.1 C333.1 C340.1 C345.1 C377.1 C379.1 CN5.1 CN14.16 D8.1 D9.2 EC5.2 EC28.1 L17.2 L18.2 PC198.2 PD11.1 PR4.1 PR214.2 PU11.5 R57.2 R182.1 R190.1 R200.1 R207.2 R224.1 R228.1 R237.1 R261.1 R267.1 R276.2 R279.1 R389.1 R393.1 RP3.5 RP3.10 RP4.5 RP4.10 U9.15 U11.26 U11.50 U11.92 U11.106 U11.114 U11.121
+3VS5: C307.2 C316.1 C317.1 C355.1 C491.2 C499.2 C720.2 C786.1 CN9.7 EC49.2 PC92.1 PC104.1 PC115.1 PJP4.2 PR104.1 PR111.1 PU5.6 PU5.7 PU8.1 PU8.2 PU8.6 PU8.7 Q17.1 Q7031.1 R168.2 R169.2 R173.2 R259.2 R356.2 R357.2 R358.2 R359.2 R360.2 R361.2 R362.2 R363.2 R364.2 R502.2 R563.1 R626.2 R7466.1 R7469.1 U15.1 U15.13 U25.AH10 U26.4 U26.5
+3VSPI: C713.2 C714.1 R491.2 R500.1 R502.1 R503.1 U23.8 U24.8
+3VSUS: C577.1 CN16.6 PR117.1 R401.2 R403.2 R412.1 R415.1
+3VSUS_S2: PC95.1 PC96.1 PR117.2 PU5.8 PU5.9
+5V: C512.1 C513.1 C517.1 C519.1 C566.1 C597.1 C704.2 C706.1 C725.1 C773.1 C775.1 C777.1 C787.1 CN11.3 CN11.8 CN12.1 EC57.2 F1.2 FAN1.1 HD17.8 HD17.9 HD17.10 L30.1 L31.2 L34.2 L42.2 L47.2 L60.1 PR114.2 Q20.3 Q39.3 R90.1 R374.1 R413.2 R422.2 R7478.1 U17.1 U22.1 VC2.1
+5V_AMP: C801.2 C802.2 L47.1 R611.2 R612.2 U28.12 U28.20
+5V_AVDD: C553.1 C558.2 C559.1 C589.1 C596.1 L31.1 R432.1 U17.5 U20.27 U20.38
+5V_CAM: L59.1 PC252.1 PC253.1 PQ43.4 PR237.1
+5V_CAM_C: C8777.1 C8778.1 CN2.9 CN2.10 L59.2 L60.2
+5V_CAM_ONG: PQ41.2 PQ42.3 PQ44.2 PR245.1 PR246.2
+5V_DVDD: C535.1 C543.1 C550.1 C556.1 L30.2 U20.39 U20.45
+5V_HDMIC: C313.1 C314.1 CN24.18 D3.2 D5.2 F1.1
+5V_LED_KBLIGHT: C384.1 C385.1 CN10.3 CN10.4 Q20.1
+5V_ODD: C292.2 C296.2 C721.2 C722.2 C723.2 ODD14.9 ODD14.10 ODD15.9 ODD15.10 ODD15.11 ODD15.12 ODD15.13 ODD15.14 ODD15.15 Q39.1 R532.1
+5V_S2: PC77.1 PC78.1 PR114.1 PU5.13 PU5.14
+5V_USBP0: C764.1 C768.1 C770.1 C772.2 CN28.1 R598.1 R599.1 R600.1 U27.6 U27.7 U27.8 VC3.2
+5V_USBP1: C341.2 C747.1 C758.2 C760.1 C763.1 CN25.1 R598.2 R599.2 R600.2 U10.12 VC4.2
+5VPCU: EC23.1 PC205.2 PR68.2 PR69.2 PU12.7 R381.1
+5VS5: C767.2 C769.1 C771.2 C774.2 C776.2 CN14.10 CN14.11 CN14.12 CN14.13 CN14.14 CN14.15 EC30.2 PC52.2 PC79.1 PC85.1 PC105.1 PC110.1 PC181.2 PC251.2 PJP3.2 PQ43.1 PQ43.2 PQ43.5 PQ43.6 PR97.2 PR102.1 PR127.2 PU3.15 PU5.1 PU5.2 PU5.4 PU7.12 PU8.4 PU10.21 R383.1 R595.2 R596.1 R597.1 U10.1 U27.2 U27.3 VC5.1
+5VS5_S: PC219.1 PC220.2 PC221.1 PC222.1 PC223.1 PC224.1 PJP3.1 PL20.2 PR187.2
+AVCC: C458.2 C473.2 R338.1 R7470.2 U14.7
+V1.05A_AOSCSUS: C291.2 U25.AB8
+V1.05A_SUS_PCH: TP8.1 U25.AD8 U25.AD10
+V1.05A_USB2SUS: TP9.1 U25.AH13
+V1.05A_VCCUSB3SUS: TP7.1 U25.J13
+V1.05S_ASATA3PLL: C699.2 C700.2 C710.2 L45.2 R485.1 U25.A12 U25.B11
+V1.05S_AUSB3PLL: C694.2 C695.2 C708.2 L44.2 R150.2 U25.B18 U25.B27
+V1.05S_AXCK_DCB: C289.1 C299.1 C300.1 L16.1 U25.J18 U25.K19
+V1.05S_AXCK_LCPLL: C696.1 C697.1 C707.1 L46.1 R149.1 U25.A20
+V3.3DX_1.5DX_ADO: C308.1 R171.1 R179.1 U25.AH14
+VCC_CORE: C238.1 C239.1 C240.1 C241.1 C242.1 C251.1 C252.1 C253.1 C254.1 C255.1 C267.1 C268.1 C269.1 C270.1 C271.1 C272.1 C275.1 C276.1 C277.1 C278.1 C279.1 C280.1 C283.1 C284.1 C285.1 C286.1 C287.1 C295.1 C302.1 C312.1 PC41.1 PC42.1 PC43.1 PC44.1 PC47.1 PC164.1 PC165.1 PC166.1 PL14.2 PR159.2 R501.2 U25.AB57 U25.AD57 U25.AG57 U25.C24 U25.C28 U25.C32 U25.C36 U25.C40 U25.C44 U25.C48 U25.C52 U25.C56 U25.E23 U25.E25 U25.E27 U25.E29 U25.E31 U25.E33 U25.E35 U25.E37 U25.E39 U25.E41 U25.E43 U25.E45 U25.E47 U25.E49 U25.E51 U25.E53 U25.E55 U25.E57 U25.F24 U25.F28 U25.F32 U25.F36 U25.F40 U25.F44 U25.F48 U25.F52 U25.F56 U25.F59 U25.G23 U25.G25 U25.G27 U25.G29 U25.G31 U25.G33 U25.G35 U25.G37 U25.G39 U25.G41 U25.G43 U25.G45 U25.G47 U25.G49 U25.G51 U25.G53 U25.G55 U25.G57 U25.H23 U25.J23 U25.K23 U25.K57 U25.L22 U25.M23 U25.M57 U25.P57 U25.U57 U25.W57
+VCC_TS: C21.2 C810.1 C7747.1 CN2.12 Q7031.3 R7467.2
+VCCIO_OUT: C249.1 R487.2 U25.A59
+VCCIOA_OUT: R165.1 U25.E20
+VCCRTCEXT: C311.1 U25.AE7
+VIN: C23.2 C71.2 C72.1 C91.1 C92.1 C97.1 C98.1 C101.1 C102.1 C103.1 C104.2 C110.2 C114.2 C120.2 C229.2 C230.2 C290.2 C382.2 C401.2 C641.2 C644.2 C653.2 C712.2 C715.2 C748.2 C749.2 C751.2 C752.2 C753.2 C754.2 C755.2 C761.2 C762.2 C765.2 C766.2 CN2.19 CN2.20 EC11.1 EC14.1 EC15.1 EC16.1 EC17.1 EC18.1 EC77.1 L25.1 PC12.1 PC72.1 PC167.1 PC171.1 PC187.1 PC188.1 PC190.1 PC194.1 PC241.2 PC242.1 PC243.1 PC254.1 PD10.1 PL3.2 PL15.1 PL17.2 PL18.2 PL19.2 PQ36.5 PQ36.6 PQ36.7 PQ36.8 PR52.1 PR57.1 PR65.1 PR66.1 PR173.2 PR211.2 PR222.2 PR246.1 PR247.1 R303.2 R497.2
+VIN_1.05V: PC69.2 PC70.1 PC73.2 PC185.1 PL3.1 PR103.1 PU10.8 PU10.9 PU10.22
+VIN_3VS5: PC192.2 PC195.2 PC202.1 PC203.1 PL18.1 PU11.8
+VIN_5VS5: PC189.2 PC191.2 PC193.1 PC196.1 PL17.1 PU12.8
+VIN_DDR: PC197.1 PC207.1 PC210.2 PC212.2 PL19.1 PQ32.5 PQ32.6 PQ32.7 PQ32.8 PR131.2
+VIN_VCC_CORE: PC48.1 PC49.1 PC50.1 PC169.1 PC170.1 PC172.2 PL15.2 PQ19.5 PQ30.5 PR74.2
AGND: C553.2 C558.1 C559.2 C563.1 C585.2 C586.2 C587.1 C588.2 C589.2 C594.2 C595.2 C596.2 C598.2 C599.2 C801.1 C802.1 C804.1 C805.1 C806.1 CN14.1 CN14.4 CN14.6 EC54.1 EC69.1 EC80.1 EC81.1 EC82.1 EC87.1 EC88.1 EC89.1 EC90.1 EC91.1 EC92.1 Q31.1 R423.2 R426.2 R429.2 R433.2 R434.1 R605.2 R618.1 R622.2 R623.2 R624.2 R625.2 U20.26 U20.33 U21.18 U28.3 U28.9 U28.10 U28.13 U28.19 U28.21 U28.22 U28.23 U28.24 U28.25 U28.26 U28.27 U28.28 U28.29 U28.30
DV33_18: C551.1 U19.18
GND: BAT14.7 BAT14.8 BAT14.9 BAT14.10 BAT15.7 BAT15.8 BAT15.9 BAT15.10 BAT15.11 BAT17.1 BAT17.2 BAT17.3 BAT17.4 BAT17.5 BAT17.6 BAT17.7 BAT17.8 C2.1 C10.1 C12.1 C21.1 C23.1 C25.1 C27.1 C28.1 C30.1 C31.1 C37.1 C40.2 C48.2 C49.2 C50.2 C52.2 C58.2 C60.2 C69.1 C70.1 C71.1 C72.2 C91.2 C92.2 C97.2 C98.2 C101.2 C102.2 C103.2 C104.1 C105.2 C106.2 C109.2 C110.1 C114.1 C115.2 C120.1 C125.1 C175.2 C227.2 C228.2 C229.1 C230.1 C231.2 C232.2 C233.2 C234.2 C235.1 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.1 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C257.1 C258.2 C259.2 C260.2 C261.1 C262.1 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.1 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.1 C282.1 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.1 C291.1 C292.1 C293.1 C294.2 C295.2 C296.1 C297.1 C298.2 C299.2 C300.2 C301.1 C302.2 C303.2 C304.2 C305.2 C306.2 C308.2 C309.1 C310.2 C311.2 C312.2 C313.2 C314.2 C315.1 C316.2 C317.2 C318.2 C319.1 C320.1 C321.2 C322.2 C323.2 C325.2 C326.2 C328.2 C329.2 C330.2 C332.2 C333.2 C334.1 C335.1 C337.2 C338.2 C340.2 C341.1 C342.2 C344.1 C345.2 C346.2 C347.2 C350.2 C351.1 C352.2 C356.2 C357.2 C358.2 C359.1 C360.1 C361.2 C362.1 C363.2 C364.2 C365.2 C366.1 C367.2 C368.2 C369.1 C370.1 C371.2 C372.1 C373.2 C374.1 C375.1 C376.1 C377.2 C378.1 C379.2 C380.1 C381.1 C382.1 C383.1 C384.2 C385.2 C386.2 C387.2 C388.2 C390.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.1 C402.2 C403.2 C404.2 C405.2 C408.2 C409.1 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C418.2 C419.2 C421.2 C422.2 C423.2 C424.2 C425.2 C427.2 C430.2 C431.2 C432.2 C433.2 C434.1 C435.2 C436.2 C437.2 C438.2 C441.2 C442.2 C443.2 C444.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C453.2 C454.2 C455.2 C456.2 C457.2 C458.1 C459.2 C461.2 C462.2 C463.1 C464.1 C465.2 C466.2 C467.1 C469.2 C470.2 C471.1 C472.1 C473.1 C474.2 C475.2 C476.2 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C484.2 C488.2 C489.2 C490.2 C491.1 C492.2 C493.2 C494.2 C495.2 C496.2 C497.2 C498.2 C499.1 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C507.2 C508.2 C509.2 C510.2 C511.2 C512.2 C513.2 C515.2 C516.2 C517.2 C518.1 C519.2 C521.2 C522.2 C523.1 C524.1 C525.1 C526.1 C527.2 C528.1 C529.2 C530.2 C531.2 C532.2 C533.1 C535.2 C536.2 C537.2 C538.2 C539.2 C542.1 C543.2 C544.2 C547.2 C548.2 C550.2 C551.2 C552.2 C554.1 C555.2 C556.2 C557.1 C560.2 C561.1 C564.2 C565.1 C566.2 C567.2 C568.2 C569.2 C570.2 C572.2 C573.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.2 C581.2 C582.2 C597.2 C608.1 C614.1 C641.1 C644.1 C647.2 C649.2 C650.2 C651.2 C652.2 C653.1 C694.1 C695.1 C696.2 C697.2 C699.1 C700.1 C702.2 C703.2 C704.1 C706.2 C707.2 C708.1 C710.1 C712.1 C713.1 C714.2 C715.1 C716.2 C717.2 C718.1 C719.1 C720.1 C721.1 C722.1 C723.1 C724.1 C725.2 C726.1 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.1 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.1 C749.1 C751.1 C752.1 C753.1 C754.1 C755.1 C758.1 C760.2 C761.1 C762.1 C763.2 C764.2 C765.1 C766.1 C767.1 C768.2 C769.2 C770.2 C771.1 C772.1 C773.2 C774.1 C775.2 C776.1 C777.2 C786.2 C787.2 C810.2 C1027.1 C1028.2 C7747.2 C7748.1 C8739.2 C8742.2 C8743.2 C8744.2 C8776.2 C8777.2 C8778.2 C8781.1 C8784.1 CN2.1 CN2.4 CN2.7 CN2.16 CN2.17 CN2.24 CN2.30 CN2.33 CN2.36 CN2.39 CN5.4 CN5.5 CN8.6 CN8.12 CN8.15 CN8.18 CN8.21 CN8.24 CN8.27 CN8.30 CN8.31 CN8.34 CN8.37 CN8.40 CN8.43 CN8.46 CN8.49 CN8.55 CN8.60 CN9.8 CN9.10 CN9.12 CN9.14 CN10.1 CN10.2 CN11.2 CN11.4 CN12.2 CN12.3 CN14.8 CN14.21 CN14.24 CN14.27 CN14.30 CN15.3 CN15.6 CN15.12 CN15.13 CN15.14 CN15.15 CN16.3 CN20.3 CN20.4 CN20.6 CN22.4 CN22.9 CN22.15 CN22.18 CN22.21 CN22.26 CN22.27 CN22.29 CN22.34 CN22.35 CN22.37 CN22.40 CN22.43 CN22.50 CN22.53 CN22.54 CN24.2 CN24.5 CN24.8 CN24.11 CN24.17 CN24.20 CN24.21 CN24.22 CN24.23 CN25.4 CN25.7 CN25.10 CN25.11 CN25.12 CN25.13 CN26.4 CN26.9 CN26.15 CN26.18 CN26.21 CN26.26 CN26.27 CN26.29 CN26.34 CN26.35 CN26.37 CN26.40 CN26.43 CN26.50 CN26.53 CN26.54 CN27.2 CN28.4 CN28.7 CN28.10 CN28.11 CN28.12 CN28.13 CN29.1 CN29.3 CN29.21 CN29.27 CN29.33 CN29.39 CN29.45 CN29.51 CN29.57 CN29.69 CN29.71 CN29.73 CN29.75 CN31.1 D7.2 EC1.1 EC2.2 EC3.1 EC4.2 EC5.1 EC6.2 EC7.2 EC8.2 EC9.2 EC10.2 EC11.2 EC12.2 EC13.2 EC14.2 EC15.2 EC16.2 EC17.2 EC18.2 EC19.2 EC20.2 EC21.2 EC22.1 EC23.2 EC24.1 EC25.1 EC26.1 EC27.1 EC28.2 EC29.1 EC30.1 EC31.2 EC32.2 EC33.2 EC34.2 EC35.2 EC36.2 EC37.1 EC38.2 EC39.2 EC40.2 EC41.2 EC42.1 EC43.2 EC44.2 EC45.1 EC46.2 EC47.2 EC48.2 EC49.1 EC50.2 EC51.2 EC52.2 EC53.2 EC54.2 EC55.2 EC56.2 EC57.1 EC58.2 EC59.2 EC60.1 EC61.1 EC62.1 EC63.2 EC64.2 EC65.1 EC66.2 EC67.2 EC68.2 EC69.2 EC70.2 EC71.2 EC73.2 EC74.2 EC75.2 EC76.2 EC77.2 EC78.2 EC79.2 EC80.2 EC81.2 EC82.2 EC84.2 EC85.1 EC86.2 EC87.2 EC88.2 EC89.2 EC90.2 EC91.2 EC92.2 FAN1.3 FAN1.5 FAN1.6 H1.1 H2.1 H3.1 H5.1 H7.1 H9.1 H10.1 H11.1 H13.1 H14.1 H14.2 H14.3 H14.4 H15.1 H16.1 H18.1 H19.1 H20.1 H22.1 H26.1 H27.1 H27.2 H28.1 HD17.1 HD17.4 HD17.7 J1.2 JDIM1.2 JDIM1.3 JDIM1.8 JDIM1.9 JDIM1.11 JDIM1.13 JDIM1.14 JDIM1.19 JDIM1.20 JDIM1.25 JDIM1.26 JDIM1.28 JDIM1.31 JDIM1.32 JDIM1.37 JDIM1.38 JDIM1.43 JDIM1.44 JDIM1.46 JDIM1.48 JDIM1.49 JDIM1.54 JDIM1.55 JDIM1.60 JDIM1.61 JDIM1.63 JDIM1.65 JDIM1.66 JDIM1.71 JDIM1.72 JDIM1.127 JDIM1.128 JDIM1.133 JDIM1.134 JDIM1.136 JDIM1.138 JDIM1.139 JDIM1.144 JDIM1.145 JDIM1.150 JDIM1.151 JDIM1.153 JDIM1.155 JDIM1.156 JDIM1.161 JDIM1.162 JDIM1.167 JDIM1.168 JDIM1.170 JDIM1.172 JDIM1.173 JDIM1.178 JDIM1.179 JDIM1.184 JDIM1.185 JDIM1.187 JDIM1.189 JDIM1.190 JDIM1.195 JDIM1.196 JDIM1.207 JDIM1.208 JDIM2.2 JDIM2.3 JDIM2.8 JDIM2.9 JDIM2.11 JDIM2.13 JDIM2.14 JDIM2.19 JDIM2.20 JDIM2.25 JDIM2.26 JDIM2.28 JDIM2.31 JDIM2.32 JDIM2.37 JDIM2.38 JDIM2.43 JDIM2.44 JDIM2.46 JDIM2.48 JDIM2.49 JDIM2.54 JDIM2.55 JDIM2.60 JDIM2.61 JDIM2.63 JDIM2.65 JDIM2.66 JDIM2.71 JDIM2.72 JDIM2.127 JDIM2.128 JDIM2.133 JDIM2.134 JDIM2.136 JDIM2.138 JDIM2.139 JDIM2.144 JDIM2.145 JDIM2.150 JDIM2.151 JDIM2.153 JDIM2.155 JDIM2.156 JDIM2.161 JDIM2.162 JDIM2.167 JDIM2.168 JDIM2.170 JDIM2.172 JDIM2.173 JDIM2.178 JDIM2.179 JDIM2.184 JDIM2.185 JDIM2.187 JDIM2.189 JDIM2.190 JDIM2.195 JDIM2.196 JDIM2.205 JDIM2.206 L19.1 ODD14.1 ODD14.4 ODD14.7 ODD14.12 ODD14.13 ODD14.14 ODD14.15 ODD15.1 ODD15.4 ODD15.7 ODD15.17 ODD15.18 ODD15.19 ODD15.20 PC1.1 PC5.1 PC7.1 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC34.2 PC35.2 PC37.2 PC38.2 PC39.2 PC41.2 PC42.2 PC43.2 PC44.2 PC45.1 PC46.1 PC47.2 PC48.2 PC49.2 PC50.2 PC52.1 PC57.1 PC64.2 PC65.1 PC66.2 PC67.1 PC68.2 PC69.1 PC70.2 PC71.1 PC72.2 PC73.1 PC74.2 PC75.2 PC76.2 PC77.2 PC78.2 PC79.2 PC80.2 PC82.2 PC85.2 PC86.2 PC87.2 PC92.2 PC93.2 PC95.2 PC96.2 PC98.2 PC101.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC124.2 PC126.2 PC127.2 PC128.2 PC130.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.1 PC169.2 PC170.2 PC171.2 PC172.1 PC175.2 PC176.2 PC177.2 PC178.2 PC179.2 PC181.1 PC182.2 PC183.1 PC184.1 PC185.2 PC186.2 PC187.2 PC188.2 PC189.1 PC190.2 PC191.1 PC192.1 PC193.2 PC194.2 PC195.1 PC196.2 PC197.2 PC198.1 PC199.1 PC201.2 PC202.2 PC203.2 PC205.1 PC206.1 PC207.2 PC208.2 PC209.1 PC210.1 PC211.1 PC212.1 PC215.2 PC216.1 PC217.1 PC218.2 PC219.2 PC220.1 PC221.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC229.1 PC230.2 PC231.2 PC232.2 PC233.2 PC235.2 PC236.2 PC237.2 PC239.1 PC241.1 PC242.2 PC243.2 PC250.1 PC251.1 PC252.2 PC253.2 PC254.2 PD1.2 PD2.2 PD8.2 PD9.2 PD10.2 PQ1.1 PQ5.1 PQ6.1 PQ9.1 PQ12.1 PQ13.1 PQ14.1 PQ15.1 PQ15.2 PQ15.3 PQ16.1 PQ17.1 PQ18.1 PQ29.1 PQ29.2 PQ29.3 PQ31.1 PQ31.2 PQ31.3 PQ34.1 PQ35.1 PQ37.1 PQ37.2 PQ37.3 PQ40.1 PQ41.1 PQ42.1 PQ44.1 PR18.2 PR20.1 PR55.2 PR56.2 PR71.1 PR72.1 PR105.1 PR122.1 PR123.2 PR134.2 PR143.2 PR162.2 PR167.2 PR172.2 PR174.2 PR179.2 PR183.2 PR206.1 PR210.1 PR213.2 PR215.1 PR218.2 PR224.2 PR245.2 PR248.2 PU1.14 PU1.21 PU1.22 PU1.23 PU1.24 PU1.25 PU3.11 PU4.2 PU5.11 PU5.15 PU7.1 PU7.14 PU7.21 PU8.11 PU8.15 PU10.4 PU10.12 PU10.13 PU10.14 PU10.15 PU10.19 PU11.9 PU12.9 Q1.1 Q3.1 Q3.4 Q13.1 Q18.1 Q19.1 Q21.1 Q22.1 Q25.1 Q26.1 Q28.1 Q30.1 Q34.1 Q34.4 Q37.1 Q40.1 Q41.1 Q41.4 Q7030.1 R4.2 R6.2 R31.1 R39.1 R145.1 R148.2 R152.2 R154.1 R160.1 R161.1 R162.1 R166.2 R167.1 R174.1 R175.1 R176.1 R193.2 R204.1 R205.1 R223.1 R235.2 R236.1 R239.2 R240.1 R245.2 R248.1 R249.2 R250.2 R251.2 R258.1 R273.2 R284.2 R293.2 R304.2 R309.1 R315.1 R320.2 R323.2 R326.1 R328.1 R335.2 R336.2 R339.2 R340.2 R341.2 R343.2 R345.1 R346.1 R348.2 R349.2 R351.2 R369.2 R370.2 R371.1 R372.2 R373.2 R385.1 R411.2 R416.1 R419.1 R420.1 R439.1 R454.2 R483.2 R484.2 R492.2 R495.1 R508.2 R537.2 R542.2 R543.2 R545.2 R555.1 R558.1 R562.1 R564.1 R578.2 R580.1 R583.1 R584.1 R592.1 R593.2 R618.2 R7482.1 R8515.2 U2.2 U8.33 U9.4 U9.7 U9.13 U9.17 U10.14 U10.17 U11.1 U11.27 U11.49 U11.91 U11.104 U12.7 U12.15 U13.5 U13.10 U13.12 U13.13 U13.15 U13.16 U14.3 U14.4 U14.8 U14.13 U14.19 U14.24 U14.29 U15.10 U15.21 U15.25 U15.26 U15.27 U15.28 U15.29 U15.30 U15.31 U15.32 U15.33 U15.34 U16.5 U17.2 U18.4 U18.11 U18.18 U18.25 U19.33 U20.42 U20.49 U21.4 U21.12 U21.21 U21.22 U21.23 U21.24 U21.25 U21.26 U21.27 U21.28 U21.29 U21.30 U22.2 U23.4 U24.4 U25.A11 U25.A14 U25.A18 U25.A24 U25.A28 U25.A32 U25.A36 U25.A40 U25.A44 U25.A48 U25.A52 U25.A56 U25.AA1 U25.AA58 U25.AB7 U25.AB10 U25.AB20 U25.AB22 U25.AC61 U25.AD3 U25.AD21 U25.AD63 U25.AE5 U25.AE10 U25.AE58 U25.AF11 U25.AF12 U25.AF14 U25.AF15 U25.AF17 U25.AF18 U25.AG1 U25.AG11 U25.AG21 U25.AG23 U25.AG60 U25.AG61 U25.AG62 U25.AG63 U25.AH16 U25.AH17 U25.AH19 U25.AH20 U25.AH22 U25.AH24 U25.AH28 U25.AH30 U25.AH32 U25.AH34 U25.AH36 U25.AH38 U25.AH40 U25.AH42 U25.AH44 U25.AH46 U25.AH49 U25.AH51 U25.AH53 U25.AH55 U25.AH57 U25.AJ13 U25.AJ14 U25.AJ23 U25.AJ25 U25.AJ27 U25.AJ29 U25.AJ35 U25.AJ39 U25.AJ41 U25.AJ43 U25.AJ45 U25.AJ47 U25.AJ50 U25.AJ52 U25.AJ54 U25.AJ56 U25.AJ58 U25.AJ60 U25.AJ63 U25.AK3 U25.AK23 U25.AK52 U25.AL10 U25.AL13 U25.AL17 U25.AL20 U25.AL22 U25.AL23 U25.AL26 U25.AL29 U25.AL31 U25.AL33 U25.AL36 U25.AL39 U25.AL40 U25.AL45 U25.AL46 U25.AL51 U25.AL52 U25.AL54 U25.AL57 U25.AL60 U25.AL61 U25.AM1 U25.AM17 U25.AM23 U25.AM31 U25.AM52 U25.AN7 U25.AN17 U25.AN23 U25.AN31 U25.AN32 U25.AN35 U25.AN36 U25.AN39 U25.AN40 U25.AN42 U25.AN43 U25.AN45 U25.AN46 U25.AN48 U25.AN49 U25.AN51 U25.AN52 U25.AN60 U25.AN63 U25.AP3 U25.AP10 U25.AP17 U25.AP20 U25.AP22 U25.AP23 U25.AP26 U25.AP29 U25.AP31 U25.AP38 U25.AP39 U25.AP48 U25.AP52 U25.AP54 U25.AP57 U25.AR5 U25.AR11 U25.AR15 U25.AR17 U25.AR23 U25.AR31 U25.AR33 U25.AR39 U25.AR43 U25.AR49 U25.AR52 U25.AT13 U25.AT35 U25.AT37 U25.AT40 U25.AT42 U25.AT43 U25.AT46 U25.AT49 U25.AT61 U25.AT62 U25.AT63 U25.AU1 U25.AU16 U25.AU18 U25.AU20 U25.AU22 U25.AU24 U25.AU26 U25.AU28 U25.AU30 U25.AU33 U25.AU51 U25.AU53 U25.AU55 U25.AU57 U25.AU59 U25.AV8 U25.AV14 U25.AV16 U25.AV20 U25.AV24 U25.AV28 U25.AV33 U25.AV34 U25.AV36 U25.AV39 U25.AV41 U25.AV43 U25.AV46 U25.AV49 U25.AV51 U25.AV55 U25.AV59 U25.AW4 U25.AW16 U25.AW24 U25.AW33 U25.AW35 U25.AW37 U25.AW40 U25.AW42 U25.AW44 U25.AW47 U25.AW50 U25.AW51 U25.AW59 U25.AW60 U25.AY4 U25.AY6 U25.AY11 U25.AY16 U25.AY18 U25.AY22 U25.AY24 U25.AY26 U25.AY30 U25.AY33 U25.AY51 U25.AY53 U25.AY57 U25.AY59 U25.B4 U25.B20 U25.B24 U25.B26 U25.B28 U25.B32 U25.B36 U25.B40 U25.B44 U25.B48 U25.B52 U25.B56 U25.B60 U25.C11 U25.C14 U25.C18 U25.C20 U25.C25 U25.C27 U25.C38 U25.C39 U25.C57 U25.D2 U25.D5 U25.D8 U25.D12 U25.D14 U25.D18 U25.D21 U25.D23 U25.D25 U25.D26 U25.D27 U25.D29 U25.D30 U25.D31 U25.D33 U25.D34 U25.D35 U25.D37 U25.D38 U25.D39 U25.D41 U25.D42 U25.D43 U25.D45 U25.D46 U25.D47 U25.D49 U25.D50 U25.D51 U25.D53 U25.D54 U25.D55 U25.D57 U25.D59 U25.D62 U25.D63 U25.E11 U25.E17 U25.F20 U25.F26 U25.F30 U25.F34 U25.F38 U25.F42 U25.F46 U25.F50 U25.F54 U25.F58 U25.F61 U25.G3 U25.G5 U25.G6 U25.G8 U25.G18 U25.G22 U25.H13 U25.H17 U25.H57 U25.J10 U25.J22 U25.J59 U25.J63 U25.K1 U25.K12 U25.L7 U25.L13 U25.L15 U25.L17 U25.L18 U25.L20 U25.L58 U25.L61 U25.M22 U25.N3 U25.N10 U25.N21 U25.P22 U25.P59 U25.P62 U25.P63 U25.R8 U25.R10 U25.R22 U25.T1 U25.T58 U25.U9 U25.U20 U25.U22 U25.U61 U25.V3 U25.V7 U25.V10 U25.V23 U25.V58 U25.W20 U25.W22 U25.Y10 U25.Y59 U25.Y63 U26.2 U27.1 U8021.10 U8021.21 U8021.25 U8021.26 U8021.27 U8021.28 U8021.29 U8021.30 U8021.31 U8021.32 U8021.33 U8021.34 VC1.2 VC2.2 VC3.1 VC4.1 VC5.2 VC6.2 Y1.2 Y1.4 Y2.2 Y2.4 Y3.2 Y3.4
PVCC2: C410.1 C411.1 C421.1 C422.1 C424.1 C427.1 C435.1 C441.1 L25.2 R338.2 R353.2 R354.2 U14.15 U14.16 U14.27 U14.28
VCC_SENSE: PR101.2 R501.1 U25.E63
VCCST_PWRGD_XDP: CN8.50 R289.2
VSS_SENSE: PR100.2 R508.1 U25.E62
1P35V_BOOT: PR119.2 PU7.18
1P35V_CS: PR122.2 PU7.13
1P35V_FB: PR128.1 PR134.1 PU7.6
1P35V_LGATE: PQ31.4 PU7.15
1P35V_PHASE: PC90.2 PL22.1 PQ31.5 PQ31.6 PQ31.7 PQ31.8 PQ32.1 PQ32.2 PQ32.3 PR186.2 PU7.16
1P35V_S5: PC114.1 PR130.2 PU7.8
1P35V_TON: PR131.1 PU7.9
1P35V_UGATE: PQ32.4 PU7.17
1P35V_VDDQ: PR128.2 PR189.1 PU7.5
1P35V_VID: PR127.1 PU7.11
3D_CAM_EN: PQ42.2 R8558.2 R8561.1
3D_FW_GPIO: CN2.8 R8562.1
1237BSTPCH: PR165.2 PU10.20
1237BSTPCH_S: PC180.1 PR165.1
1237ENPCH: PC183.2 PR169.2 PU10.2
1237FBPCH: PR171.1 PR172.1 PU10.5
1237FBPCH_S: PR170.1 PR171.2
1237LX: PC180.2 PL16.1 PR168.2 PU10.10 PU10.11 PU10.16 PU10.17 PU10.18
1237PFMPCH: PR167.1 PU10.3
1237PGPCH: PR166.2 PU10.1
1237SSPCH: PC182.1 PU10.23
8008LX1.5V: PL2.1 PU4.3
51216S3: PC113.1 PR129.2 PU7.7 R382.2
81101_BST: PC51.1 PU3.8
81101_HG: PR70.1 PU3.9
81101_HG_G: PQ19.4 PQ30.4 PR70.2
81101_LG: PQ15.4 PQ29.4 PU3.12
81101_PH: PC51.2 PL14.1 PQ15.5 PQ19.1 PQ19.2 PQ19.3 PQ29.5 PQ30.1 PQ30.2 PQ30.3 PR158.2 PR161.2 PU3.10
81101COM: PC58.2 PR98.2 PU3.23
81101DIFFOUT: PR94.1 PR95.1 PU3.25
81101FB: PC58.1 PC62.1 PC63.2 PR94.2 PR99.1 PU3.24
81101ILIM: PR92.2 PU3.21
81101IOUT: PC56.1 PR88.2 PU3.20
81101ROSC: PR93.2 PU3.22
81181_AGND: PC53.1 PC56.2 PC61.1 PC173.2 PC174.2 PR72.2 PR88.1 PR93.1 PR163.2 PR164.1 PU3.29
+AUDIO_5V_AVDD: C598.1 C599.1 L42.1 U21.9
+AUDIO_5V_VDD: C567.1 C568.1 C579.1 C580.1 C1027.2 L34.1 R417.1 R418.1 R7479.2 R7481.2 R7487.2 U21.3 U21.13 U22.5
+BATCHG: PC124.1 PC126.1 PC128.1 PC130.1 PC244.2 PD8.1 PL5.1 PL7.1 PQ39.1 PQ39.2 PQ39.3 PR7.1 PR137.2 PR138.2
+G_SEN_PW: C390.1 C395.1 R299.2 R301.2 R308.2 U13.1 U13.8 U13.14
+PCH_VCCDSW: C307.1 C309.2 U25.AG19 U25.AG20
+PRWSRC: EC6.1 EC7.1 EC8.1 EC9.1 PC119.1 PQ20.3 PQ39.5 PR21.1 PR211.1 PR212.2 PR221.2
+SMDDR_VREF_DIMM: C436.1 C446.1 C500.1 C515.1 JDIM1.126 JDIM2.126 R370.1 R379.2 R380.2
+SMDDR_VREF_DQ0: C469.1 C470.1 JDIM2.1 R350.2 R351.1 R352.2
+SMDDR_VREF_DQ1: C457.1 C459.1 JDIM1.1 R319.2 R320.1 R331.2
+VA: EC1.2 PD7.2 PL4.2 PL6.2 PQ33.5 PQ33.6 PQ33.7 PQ33.8 PR208.2
+VA_AC: CN20.1 CN20.2 PC5.2 PL4.1 PL6.1
+VA_AIR: PD7.1 PR144.1 PR216.1
+VAD: PC118.1 PC231.1 PD9.1 PQ20.4 PQ33.1 PQ33.2 PQ33.3 PQ38.4 PR11.1 PR16.1
A2_DE0: R8519.1 U8021.16
A2_DE1: R8513.1 U8021.18
A2_EQ0: R8518.1 U8021.17
A2_EQ1: R8512.1 U8021.15
A_DE0: R359.1 U15.16
A_DE1: R358.1 U15.18
A_EQ0: R357.1 U15.17
A_EQ1: R362.1 U15.15
AC_LED_ON#: PQ13.2 PQ18.2 U11.28
AC_PRESENT_EC: R281.2 U25.AJ8
ACC_LED#: CN14.20 EC79.1 R538.1 U25.V1
ACCEL_INTA#: C297.2 D10.2 R552.1 U25.Y3
ACCEL_INTA#_R: D10.1 U13.11
ACIN: EC75.1 PQ16.2 PQ17.2 PR217.1 PR218.1 PU1.5 Q41.5 U11.97 VC6.1
ACZ_BCLK: R591.2 U25.AW8
ACZ_RST#: R590.2 U25.AU8
ACZ_RST#_AUDIO: C582.1 Q29.1 R590.1 U20.11
ACZ_SDIN0: EC60.2 R410.1 U25.AY10
ACZ_SDOUT: R581.2 R589.2 U25.AU11
ACZ_SDOUT_AUDIO: EC61.2 R589.1 U20.5
ACZ_SPKR: Q31.2 U25.V2
ACZ_SYNC: R574.2 R585.2 U25.AV11
ACZ_SYNC_AUDIO: EC65.2 R585.1 U20.10
AD_AIR: PC66.1 PR143.1 PR144.2 U11.69
AD_ID: C386.1 CN20.5 EC2.1 R298.2
AD_TYPE: D7.1 R294.1 U11.67
ADAPTER_SEL_EC: R279.2 R284.1 U11.73
ALERT#: PR81.2 PR82.1 PU3.4
AMP_BEEP: C584.2 U20.12
AMP_BEEP_L: C584.1 C594.1 R427.2 R433.1
AMP_BEEP_R2: C583.2 R427.1
AMP_CLK: R612.1 U28.8
AMP_DAT: R611.1 U28.7
AMP_PD#_R: D13.3 R613.2 U28.6
B2_DE0: R8520.1 U8021.3
B2_DE1: R8514.1 U8021.6
B2_EQ0: R8516.1 U8021.2
B2_EQ1: R8521.1 U8021.4
B_DE0: R360.1 U15.3
B_DE1: R363.1 U15.6
B_EQ0: R356.1 U15.2
B_EQ1: R361.1 U15.4
B_TEMP_MBAT: BAT14.6 BAT15.6 BAT17.9 PC1.2 PR3.1 PR4.2
BATDIS_G: PC118.2 PC119.2 PQ20.1 PR22.2
BATDIS_ID_DOD: PC244.1 PQ39.4 PR9.1
BATSHIP: PQ1.2 U11.113
BATT+: BAT14.1 BAT14.2 BAT15.1 BAT15.2 BAT17.13 BAT17.14 BAT17.15 BAT17.16 BAT17.17 BAT17.18 BAT17.19 BAT17.20 EC84.1 EC85.2 EC86.1 PC127.1 PL5.2 PL7.2
BIOS_CS#: R220.1 U11.101
BIOS_RD#: R212.1 U11.103
BIOS_SPI_CLK: R225.1 U11.105
BIOS_WP#: R490.1 R491.1 TP25.1 U23.3 U24.3
BIOS_WR#: R226.1 U11.102
BIT_CLK_AUDIO: C741.2 EC62.2 R591.1 U20.6
BLON_CON: C2.2 CN2.23 D1.1 R6.1
BOARD_ID0: R174.2 R539.1 U25.AG6
BOARD_ID1: R199.1 R205.2 U25.AP1
BOARD_ID2: R558.2 R559.1 U25.AL4
BOARD_ID3: R248.2 R255.1 U25.AT5
BOARD_ID4: R175.2 R540.1 U25.AG5
BOARD_ID5: R167.2 R549.1 U25.AB6
BOARD_ID6: R161.2 R164.1 U25.AD5
BOARD_ID7: R198.1 R204.2 U25.AN3
BOARD_ID8: R160.2 R163.1 U25.AD7
BQACDRV: PR22.1 PU1.4
BQACN: PC9.1 PC240.2 PR222.1 PU1.1
BQACP: PC7.2 PC240.1 PR221.1 PU1.2
BQB_1: PC234.1 PD4.1 PR19.1
BQB_2: PR19.2 PU1.17
BQBATDRV: PR9.2 PU1.11
BQCLK: PR15.1 PU1.9
BQCMSRC: PR212.1 PU1.3
BQDATA: PR13.1 PU1.8
BQHIDRV: PQ36.4 PU1.18
BQIOUT: PC232.1 PR12.2 PU1.7
BQLODRV: PQ37.4 PU1.15
BQLR: PL8.2 PR136.2 PR137.1
BQPHASE: PC234.2 PL8.1 PQ36.1 PQ36.2 PQ36.3 PQ37.5 PQ37.6 PQ37.7 PQ37.8 PR14.2 PU1.19
BQSRN: PR219.1 PU1.12
BQSRP: PR220.1 PU1.13
BQVCC: PC13.1 PR11.2 PU1.20
BRIGHT: R27.2 R28.1 R58.2 R440.1
BT_COMBO_EN#: R94.2 R512.1 U25.U4
BT_OFF: Q3.5 R180.1 U25.AM3
C_IN_CLK: C327.2 R219.2 R222.1
C_IN_CLK#: C324.2 R214.1 R215.2
C_TX0_HDMI+: C343.2 CN24.7 R234.1 R241.1
C_TX0_HDMI-: C339.2 CN24.9 R233.1 R234.2
C_TX1_HDMI+: C336.2 CN24.4 R231.1 R232.1
C_TX1_HDMI-: C331.2 CN24.6 R230.1 R231.2
C_TX2_HDMI+: C354.2 CN24.1 R247.1 R253.1
C_TX2_HDMI-: C349.2 CN24.3 R246.1 R247.2
C_TXC_HDMI+: CN24.10 R217.1 R219.1
C_TXC_HDMI-: CN24.12 R215.1 R217.2
CAP+: C562.2 U20.36
CAP-: C562.1 U20.35
CAPSLED#: R397.2 U11.34
CAPSLED#_R: CN13.5 R397.1
CATERR#: TP31.1 U25.K61
CFG0: R288.1 U25.AC60
CFG1: CN8.36 U25.AC62
CFG2: CN8.38 U25.AC63
CFG3: CN8.39 R270.2 R543.1 U25.AA63
CFG4: CN8.44 R542.1 U25.AA60
CFG5: CN8.45 U25.Y62
CFG6: CN8.47 U25.Y61
CFG7: CN8.48 U25.Y60
CFG8: CN8.26 U25.V62
CFG9: CN8.25 U25.V61
CFG10: CN8.23 U25.V60
CFG11: CN8.22 U25.U60
CFG12: CN8.17 U25.T63
CFG13: CN8.16 U25.T62
CFG14: CN8.14 U25.T61
CFG15: CN8.13 U25.T60
CFG16: CN8.28 U25.AA62
CFG17: CN8.29 U25.AA61
CFG18: CN8.19 U25.U63
CFG19: CN8.20 U25.U62
CFG_RCOMP: R537.1 U25.V63
CK_XDP_N: CN8.10 RP1.3
CK_XDP_N_R: RP1.4 U25.B35
CK_XDP_P: CN8.11 RP1.1
CK_XDP_P_R: RP1.2 U25.A35
CLK_24M_DEBUG: CN22.19 EC29.2 R91.2 R254.2
CLK_24M_KBC: EC26.2 R242.2 R272.1 U11.13
CLK_PCI_EC_R: R242.1 U25.AN15
CLK_PCI_LPC_R: R243.1 R254.1 U25.AP15
CLK_PCI_TPM: EC27.2 R243.2 R391.2 U18.21
CLK_PCIE_CRN: U19.6 U25.A39
CLK_PCIE_CRP: U19.5 U25.B39
CLK_PCIE_LANN: U8.16 U25.B38
CLK_PCIE_LANP: U8.15 U25.C37
CLK_PCIE_WLANN: CN22.11 U25.C41
CLK_PCIE_WLANP: CN22.13 U25.B42
CLKGEN_RTC_X1: R582.1 U9.9
CLKRUN#: R526.2 U11.93 U25.V5
COMBO-DET: R610.2 U20.46
COMBO-DET_R: C595.1 R434.2 R435.1 R610.1
CPIO29: TP51.1 U25.AM5
CRY1: R281.1 U11.19
CSCOMP: PC54.1 PC55.1 PR90.1 PR92.1 PR160.1 PU3.19
CSON: PC237.1 PC238.2 PR138.1 PR219.2
CSOP: PC236.1 PC238.1 PR136.1 PR220.2
CSREF: PC53.2 PR75.1 PU3.17
CSSUM: PC54.2 PC55.2 PR80.1 PR85.1 PU3.18
DC_TEST_A3_B3: U25.A3 U25.B3
DC_TEST_A61_B61: U25.A61 U25.B61
DC_TEST_AY2_AW2: U25.AW2 U25.AY2
DC_TEST_AY3_AW3: U25.AW3 U25.AY3
DC_TEST_AY61_AW61: U25.AW61 U25.AY61
DC_TEST_AY62_AW62: U25.AW62 U25.AY62
DC_TEST_B62_B63: U25.B62 U25.B63
DC_TEST_C1_C2: U25.C1 U25.C2
DDR3_DRAMRST#: C471.2 C472.2 JDIM1.30 JDIM2.30 R266.1 U25.AV15
DDR_PG_CNTL: Q26.2 U25.AV61
DDR_THERMDA: C534.1 Q23.2 Q23.3 U16.2
DDR_THERMDC: C534.2 Q23.1 U16.3
DDR_VTT_PG_CTRL: Q24.2 Q25.3 R373.1 R382.1 R383.2
DDR_VTTREF: PC107.1 PR126.1
DEEP_PWRLED#: C60.1 CN5.2 CN14.18 EC4.1 Q1.3 R57.1
DEVSLP0: R515.1 U25.P2
DEVSLP1: R318.1 R601.1 R602.1 U25.L2
DEVSLP2: R499.1 U25.N5
DGPU_CL_HDMIP: Q40.3 R214.2 R222.2 R230.2 R232.2 R233.2 R241.2 R246.2 R253.2
DGPU_HOLD_RST#: R492.1 R493.1 U25.R5
DGPU_PROCHOT#: R8554.2 U11.77
DGPU_PROCHOT_EC#: R285.2 TP11.1 U11.71
DGPU_PWR_EN: R520.1 U25.L3
DIGITAL_CLK: C555.1 C8744.1 L58.2 R395.1
DIGITAL_CLK_L: CN31.2 L58.1
DIGITAL_D1: C569.1 C8743.1 CN31.3 R405.1
DIMM0_SA0: JDIM2.197 R348.1
DIMM0_SA1: JDIM2.201 R340.1
DIMM1_SA0: JDIM1.197 R323.1
DIMM1_SA1: JDIM1.201 R321.1
DMIC0: R405.2 U20.4
DMIC_CLK_R: R395.2 U20.2
DNBSWON#: CN8.51 CN9.11 R7469.2 U11.21 U25.AL7
DPWROK: R579.1 R586.1 U25.AV5
DPWROK_EC: R586.2 R593.1 U11.87
DSW_WAKE#: R143.2 TP3.1
DSWVRMEN: R576.1 U25.AW7
EC_AOCS: Q18.2 U11.84
EC_PCIE_WAKE#: EC13.1 Q4.3 R261.2 U11.79
EC_PECI: R206.2 U25.N62
EC_PECI_R: R206.1 U11.117
EC_PWROK: C346.1 C381.2 CN8.54 D6.1 EC24.2 R240.2 R290.1 U11.20 U25.AB5 U25.AG2 U25.AY7
EC_RCIN#: R269.1 U11.4 U25.V4
EC_RTC_RST: Q19.2 R293.1 R296.2
EC_USB_CTRL1: R275.2 R291.2
EC_USB_CTRL2: U10.7 U11.96
EC_USB_CTRL3: U10.8 U11.120
EC_WRST: C342.1 Q15.3 Q16.3 R237.2 U11.14
EDP_DISP_UTIL: TP20.1 U25.A43
EDP_RCOMP: R165.2 U25.D20
EMU_LID: R7.1 U11.81
EXT_MIC_L: CN14.5 R430.2 R435.2 R436.2
FAN1_PWM: C703.1 FAN1.2 U11.30
FAN1SIG: C702.1 FAN1.4 R482.1 U11.47
GC6_FB_EN: R139.1 U25.U7
GEN_XTAL25_IN: C326.1 U9.1 Y3.1
GEN_XTAL25_OUT: C337.1 U9.16 Y3.3
GPIO13_ULT: R218.1 U25.AT3
GPIO14_ULT: R183.1 U25.AH4
GPIO15_ULT: R8560.1 R8561.2 U25.AD6
GPIO17: R513.1 U25.T3
GPIO25_ULT: R173.1 U25.AM4
GPIO27: R626.1 U25.AN5
GPIO33_EC: D4.1 R191.2 R581.1
GPIO44_ULT: R565.1 U25.AK4
GPIO46_ULT: R541.1 U25.AG3
GPIO50_ULT: R524.1 R8562.2 U25.P3
GPIO52_ULT: R511.1 U25.L1
GPIO70_ULT: R486.1 U25.C4
GPIO76_ULT: R525.1 U25.P1
GPIO77_ULT: R514.1 U25.U6
GPU_EVENT#: R510.1 U25.L4
GPUT_CLK: R260.2 U11.16
GPUT_DATA: R216.2 U11.118
GSPI0_CLK: RP2.7 U25.L6
GSPI0_CS: RP5.7 U25.R6
GSPI0_MISO: RP6.8 U25.N6
GSPI1_CLK: RP2.6 U25.L5
GSPI1_CS: RP5.6 U25.R7
GSPI1_MISO: RP6.7 U25.N7
GSPI1_MOSI: RP6.9 U25.K2
H_CPU_SVIDALRT#: R531.1 U25.L62
H_PROCHOT#: C315.2 PR86.2 PR87.2 Q13.3 R517.1 R522.1
H_PROCHOT#_EC: Q13.2 R223.2 U11.124
H_VCCST_PWRGD: C719.2 D2.2 R289.1 R557.1 U25.B59
H_VR_ENABLE_MCP: PR91.2 R494.2 U25.F60
HD_SDIN0: R410.2 U20.8
HDMI_DET_C: C298.1 CN24.19 Q10.3 R176.2 VC1.1
HDMI_HPD_CON: Q10.1 R170.1 U25.C8
HDMI_SCLK: C318.1 CN24.15 Q14.3 R196.2
HDMI_SDATA: C321.1 CN24.16 Q14.6 R202.2
HOLD#: R500.2 R504.2 TP29.1 U23.7 U24.7
HP_EAPD: D13.1 U20.48
HPOUT_L: C545.2 C797.2 R387.1 R616.2 R624.1 U20.31
HPOUT_L_1: C797.1 U28.1
HPOUT_R: C546.2 C800.2 R388.1 R617.2 R625.1 U20.32
HPOUT_R_1: C800.1 U28.5
HWPG: C335.2 D2.1 PR107.2 PR110.2 PR111.2 PR132.1 PR166.1 PR181.2 U11.98 U12.1 U12.4 U12.10 U12.13
I2C0_SCL: RP6.1 U25.F3
I2C0_SDA: RP6.3 U25.F2
I2C1_SCL: RP6.2 U25.F1
I2C1_SDA: RP2.8 U25.G4
IDEA_G: PQ33.4 PQ38.3 PR210.2
IMVP_PWRGD: PR76.2 PR77.1 R221.2 R494.1 U25.C59
IN_CLK: C327.1 U25.B57
IN_CLK#: C324.1 U25.A57
IN_D0: C343.1 U25.A55
IN_D0#: C339.1 U25.B55
IN_D1: C336.1 U25.C58
IN_D1#: C331.1 U25.B58
IN_D2: C354.1 U25.C55
IN_D2#: C349.1 U25.C54
INT_BT_OFF#: CN22.51 Q3.3 R74.1 R90.2
INT_EDP_AUXN: C33.2 U25.A45
INT_EDP_AUXN_R: C33.1 CN2.31 R40.2
INT_EDP_AUXP: C32.2 U25.B45
INT_EDP_AUXP_R: C32.1 CN2.32 R39.2
INT_EDP_TXN0: C35.2 U25.C45
INT_EDP_TXN0_R: C35.1 CN2.35
INT_EDP_TXN1: C8780.2 U25.A47
INT_EDP_TXN1_R: C8780.1 CN2.38
INT_EDP_TXP0: C36.2 U25.B46
INT_EDP_TXP0_R: C36.1 CN2.34
INT_EDP_TXP1: C8779.2 U25.B47
INT_EDP_TXP1_R: C8779.1 CN2.37
INT_RF_OFF#: CN22.20 Q3.6 R95.1
ISOLATEB: R143.1 R144.2 R145.2 U8.20
IT8502_AGND: L19.2 U11.75
JTAG_TCK_PCH: CN8.58 R286.1 R564.2 U25.AE62
JTAG_TDI_PCH: CN8.3 R271.1 R548.2 U12.5 U25.AD61
JTAG_TDO_PCH: CN8.5 R201.2 R264.2 R271.2 R287.2 U12.2 U25.AE61
JTAG_TMS_PCH: CN8.2 R547.2 U12.9 U25.AD62
JTAGX_PCH: CN8.59 R286.2 R287.1 R554.2 R562.2 U25.AE63 U25.E60
KB_LED_EN: Q21.2 U11.31
L_SPK+: L6.2 U20.40
L_SPK+_R: C27.2 CN3.4 L6.1
L_SPK-: L5.2 U20.41
L_SPK-_R: C31.2 CN3.3 L5.1
LAD0: CN22.16 R368.1 U11.10 U25.AU14
LAD0_T: R368.2 U18.26
LAD1: CN22.14 R375.1 U11.9 U25.AW12
LAD1_T: R375.2 U18.23
LAD2: CN22.12 R394.1 U11.8 U25.AY12
LAD2_T: R394.2 U18.20
LAD3: CN22.10 R399.1 U11.7 U25.AW11
LAD3_T: R399.2 U18.17
LAN_AMBLED: C28.2 CN21.11 R21.2
LAN_AMBLED#: CN21.12 U8.27
LAN_CLKRQ: R142.2 U8.12
LAN_DISABLE#: R169.1 U25.AM7
LAN_MCTG0: R119.2 U6.7
LAN_MCTG1: R101.2 U6.2
LAN_MCTG2: R140.2 U7.7
LAN_MCTG3: R131.2 U7.2
LAN_POWER: PR135.1 U11.112
LAN_WLED: C614.2 CN21.9 R444.2
LAN_WLED#: CN21.10 R156.2 R157.2
LAN_XTAL1: C262.2 R155.1 Y2.1
LAN_XTAL25_IN: C319.2 R159.2 R208.1
LAN_XTAL25_IN_R: R208.2 U9.6
LANRSET: R154.2 U8.31
LED1: R157.1 U8.26
LED1_21232747: CN20.7 PC45.2 PQ13.3 PQ17.4 PR63.2
LED2: CN20.8 PC46.2 PQ12.3 PQ16.4 PR67.2
LFRAME#: CN22.8 EC50.1 R384.1 U11.6 U25.AV12
LFRAME#_T: R384.2 U18.22
LID_EC#: C58.1 CN5.3 R200.2 U11.123
LINEOUT_L: R614.2 U28.14
LINEOUT_L_C: C805.2 CN14.3 R614.1 R616.1
LINEOUT_R: R615.2 U28.11
LINEOUT_R_C: C806.2 CN14.2 R615.1 R617.1
LM_EN: CN11.5 R8559.2
LVDS_BLON1: R1.2 R2.1 R4.1 R5.1
M_A_A0: JDIM2.98 U25.AU36
M_A_A1: JDIM2.97 U25.AY37
M_A_A2: JDIM2.96 U25.AR38
M_A_A3: JDIM2.95 U25.AP36
M_A_A4: JDIM2.92 U25.AU39
M_A_A5: JDIM2.91 U25.AR36
M_A_A6: JDIM2.90 U25.AV40
M_A_A7: JDIM2.86 U25.AW39
M_A_A8: JDIM2.89 U25.AY39
M_A_A9: JDIM2.85 U25.AU40
M_A_A10: JDIM2.107 U25.AP35
M_A_A11: JDIM2.84 U25.AW41
M_A_A12: JDIM2.83 U25.AU41
M_A_A13: JDIM2.119 U25.AR35
M_A_A14: JDIM2.80 U25.AV42
M_A_A15: JDIM2.78 U25.AU42
M_A_BS#0: JDIM2.109 U25.AU35
M_A_BS#1: JDIM2.108 U25.AV35
M_A_BS#2: JDIM2.79 U25.AY41
M_A_CAS#: JDIM2.115 U25.AU34
M_A_CKE0: JDIM2.73 U25.AU43
M_A_CKE1: JDIM2.74 U25.AW43
M_A_CLKN0: JDIM2.103 U25.AU37
M_A_CLKN1: JDIM2.104 U25.AW36
M_A_CLKP0: JDIM2.101 U25.AV37
M_A_CLKP1: JDIM2.102 U25.AY36
M_A_CS#0: JDIM2.114 U25.AP33
M_A_CS#1: JDIM2.121 U25.AR32
M_A_DQ0: JDIM2.6 U25.AH63
M_A_DQ1: JDIM2.4 U25.AH62
M_A_DQ2: JDIM2.17 U25.AK63
M_A_DQ3: JDIM2.18 U25.AK62
M_A_DQ4: JDIM2.7 U25.AH61
M_A_DQ5: JDIM2.5 U25.AH60
M_A_DQ6: JDIM2.15 U25.AK61
M_A_DQ7: JDIM2.16 U25.AK60
M_A_DQ8: JDIM2.24 U25.AM63
M_A_DQ9: JDIM2.22 U25.AM62
M_A_DQ10: JDIM2.36 U25.AP63
M_A_DQ11: JDIM2.34 U25.AP62
M_A_DQ12: JDIM2.23 U25.AM61
M_A_DQ13: JDIM2.21 U25.AM60
M_A_DQ14: JDIM2.33 U25.AP61
M_A_DQ15: JDIM2.35 U25.AP60
M_A_DQ16: JDIM2.42 U25.AY58
M_A_DQ17: JDIM2.40 U25.AW58
M_A_DQ18: JDIM2.50 U25.AY56
M_A_DQ19: JDIM2.51 U25.AW56
M_A_DQ20: JDIM2.41 U25.AV58
M_A_DQ21: JDIM2.39 U25.AU58
M_A_DQ22: JDIM2.52 U25.AV56
M_A_DQ23: JDIM2.53 U25.AU56
M_A_DQ24: JDIM2.57 U25.AY54
M_A_DQ25: JDIM2.59 U25.AW54
M_A_DQ26: JDIM2.70 U25.AY52
M_A_DQ27: JDIM2.69 U25.AW52
M_A_DQ28: JDIM2.56 U25.AV54
M_A_DQ29: JDIM2.58 U25.AU54
M_A_DQ30: JDIM2.68 U25.AV52
M_A_DQ31: JDIM2.67 U25.AU52
M_A_DQ32: JDIM2.130 U25.AY31
M_A_DQ33: JDIM2.131 U25.AW31
M_A_DQ34: JDIM2.141 U25.AY29
M_A_DQ35: JDIM2.143 U25.AW29
M_A_DQ36: JDIM2.129 U25.AV31
M_A_DQ37: JDIM2.132 U25.AU31
M_A_DQ38: JDIM2.140 U25.AV29
M_A_DQ39: JDIM2.142 U25.AU29
M_A_DQ40: JDIM2.146 U25.AY27
M_A_DQ41: JDIM2.148 U25.AW27
M_A_DQ42: JDIM2.159 U25.AY25
M_A_DQ43: JDIM2.160 U25.AW25
M_A_DQ44: JDIM2.147 U25.AV27
M_A_DQ45: JDIM2.149 U25.AU27
M_A_DQ46: JDIM2.157 U25.AV25
M_A_DQ47: JDIM2.158 U25.AU25
M_A_DQ48: JDIM2.166 U25.AY23
M_A_DQ49: JDIM2.163 U25.AW23
M_A_DQ50: JDIM2.175 U25.AY21
M_A_DQ51: JDIM2.177 U25.AW21
M_A_DQ52: JDIM2.165 U25.AV23
M_A_DQ53: JDIM2.176 U25.AU23
M_A_DQ54: JDIM2.174 U25.AV21
M_A_DQ55: JDIM2.164 U25.AU21
M_A_DQ56: JDIM2.183 U25.AY19
M_A_DQ57: JDIM2.180 U25.AW19
M_A_DQ58: JDIM2.193 U25.AY17
M_A_DQ59: JDIM2.181 U25.AW17
M_A_DQ60: JDIM2.182 U25.AV19
M_A_DQ61: JDIM2.194 U25.AU19
M_A_DQ62: JDIM2.192 U25.AV17
M_A_DQ63: JDIM2.191 U25.AU17
M_A_DQSN0: JDIM2.10 U25.AJ61
M_A_DQSN1: JDIM2.27 U25.AN62
M_A_DQSN2: JDIM2.45 U25.AV57
M_A_DQSN3: JDIM2.62 U25.AV53
M_A_DQSN4: JDIM2.135 U25.AW30
M_A_DQSN5: JDIM2.152 U25.AV26
M_A_DQSN6: JDIM2.169 U25.AW22
M_A_DQSN7: JDIM2.186 U25.AV18
M_A_DQSP0: JDIM2.12 U25.AJ62
M_A_DQSP1: JDIM2.29 U25.AN61
M_A_DQSP2: JDIM2.47 U25.AW57
M_A_DQSP3: JDIM2.64 U25.AW53
M_A_DQSP4: JDIM2.137 U25.AV30
M_A_DQSP5: JDIM2.154 U25.AW26
M_A_DQSP6: JDIM2.171 U25.AV22
M_A_DQSP7: JDIM2.188 U25.AW18
M_A_ODT0: JDIM2.116 R366.2
M_A_ODT1: JDIM2.120 R367.2
M_A_RAS#: JDIM2.110 U25.AY34
M_A_WE#: JDIM2.113 U25.AW34
M_B_A0: JDIM1.98 U25.AP40
M_B_A1: JDIM1.97 U25.AR40
M_B_A2: JDIM1.96 U25.AP42
M_B_A3: JDIM1.95 U25.AR42
M_B_A4: JDIM1.92 U25.AR45
M_B_A5: JDIM1.91 U25.AP45
M_B_A6: JDIM1.90 U25.AW46
M_B_A7: JDIM1.86 U25.AY46
M_B_A8: JDIM1.89 U25.AY47
M_B_A9: JDIM1.85 U25.AU46
M_B_A10: JDIM1.107 U25.AK36
M_B_A11: JDIM1.84 U25.AV47
M_B_A12: JDIM1.83 U25.AU47
M_B_A13: JDIM1.119 U25.AK33
M_B_A14: JDIM1.80 U25.AR46
M_B_A15: JDIM1.78 U25.AP46
M_B_BS#0: JDIM1.109 U25.AL35
M_B_BS#1: JDIM1.108 U25.AM36
M_B_BS#2: JDIM1.79 U25.AU49
M_B_CAS#: JDIM1.115 U25.AM33
M_B_CKE0: JDIM1.73 U25.AY49
M_B_CKE1: JDIM1.74 U25.AU50
M_B_CLKN0: JDIM1.103 U25.AM38
M_B_CLKN1: JDIM1.104 U25.AK38
M_B_CLKP0: JDIM1.101 U25.AN38
M_B_CLKP1: JDIM1.102 U25.AL38
M_B_CS#0: JDIM1.114 U25.AM32
M_B_CS#1: JDIM1.121 U25.AK32
M_B_DQ0: JDIM1.36 U25.AP58
M_B_DQ1: JDIM1.34 U25.AR58
M_B_DQ2: JDIM1.22 U25.AM57
M_B_DQ3: JDIM1.24 U25.AK57
M_B_DQ4: JDIM1.21 U25.AL58
M_B_DQ5: JDIM1.23 U25.AK58
M_B_DQ6: JDIM1.33 U25.AR57
M_B_DQ7: JDIM1.35 U25.AN57
M_B_DQ8: JDIM1.41 U25.AP55
M_B_DQ9: JDIM1.39 U25.AR55
M_B_DQ10: JDIM1.53 U25.AM54
M_B_DQ11: JDIM1.51 U25.AK54
M_B_DQ12: JDIM1.40 U25.AL55
M_B_DQ13: JDIM1.42 U25.AK55
M_B_DQ14: JDIM1.52 U25.AR54
M_B_DQ15: JDIM1.50 U25.AN54
M_B_DQ16: JDIM1.4 U25.AK40
M_B_DQ17: JDIM1.6 U25.AK42
M_B_DQ18: JDIM1.17 U25.AM43
M_B_DQ19: JDIM1.18 U25.AM45
M_B_DQ20: JDIM1.16 U25.AK45
M_B_DQ21: JDIM1.15 U25.AK43
M_B_DQ22: JDIM1.5 U25.AM40
M_B_DQ23: JDIM1.7 U25.AM42
M_B_DQ24: JDIM1.68 U25.AM46
M_B_DQ25: JDIM1.70 U25.AK46
M_B_DQ26: JDIM1.57 U25.AM49
M_B_DQ27: JDIM1.59 U25.AK49
M_B_DQ28: JDIM1.69 U25.AM48
M_B_DQ29: JDIM1.67 U25.AK48
M_B_DQ30: JDIM1.56 U25.AM51
M_B_DQ31: JDIM1.58 U25.AK51
M_B_DQ32: JDIM1.129 U25.AM29
M_B_DQ33: JDIM1.131 U25.AK29
M_B_DQ34: JDIM1.143 U25.AL28
M_B_DQ35: JDIM1.140 U25.AK28
M_B_DQ36: JDIM1.130 U25.AR29
M_B_DQ37: JDIM1.132 U25.AN29
M_B_DQ38: JDIM1.141 U25.AR28
M_B_DQ39: JDIM1.142 U25.AP28
M_B_DQ40: JDIM1.147 U25.AN26
M_B_DQ41: JDIM1.146 U25.AR26
M_B_DQ42: JDIM1.148 U25.AR25
M_B_DQ43: JDIM1.149 U25.AP25
M_B_DQ44: JDIM1.158 U25.AK26
M_B_DQ45: JDIM1.160 U25.AM26
M_B_DQ46: JDIM1.159 U25.AK25
M_B_DQ47: JDIM1.157 U25.AL25
M_B_DQ48: JDIM1.177 U25.AR21
M_B_DQ49: JDIM1.164 U25.AR22
M_B_DQ50: JDIM1.174 U25.AL21
M_B_DQ51: JDIM1.165 U25.AM22
M_B_DQ52: JDIM1.163 U25.AN22
M_B_DQ53: JDIM1.176 U25.AP21
M_B_DQ54: JDIM1.175 U25.AK21
M_B_DQ55: JDIM1.166 U25.AK22
M_B_DQ56: JDIM1.180 U25.AN20
M_B_DQ57: JDIM1.182 U25.AR20
M_B_DQ58: JDIM1.194 U25.AK18
M_B_DQ59: JDIM1.191 U25.AL18
M_B_DQ60: JDIM1.193 U25.AK20
M_B_DQ61: JDIM1.192 U25.AM20
M_B_DQ62: JDIM1.183 U25.AR18
M_B_DQ63: JDIM1.181 U25.AP18
M_B_DQSN0: JDIM1.27 U25.AM58
M_B_DQSN1: JDIM1.45 U25.AM55
M_B_DQSN2: JDIM1.10 U25.AL43
M_B_DQSN3: JDIM1.62 U25.AL48
M_B_DQSN4: JDIM1.135 U25.AN28
M_B_DQSN5: JDIM1.152 U25.AN25
M_B_DQSN6: JDIM1.169 U25.AN21
M_B_DQSN7: JDIM1.186 U25.AN18
M_B_DQSP0: JDIM1.29 U25.AN58
M_B_DQSP1: JDIM1.47 U25.AN55
M_B_DQSP2: JDIM1.12 U25.AL42
M_B_DQSP3: JDIM1.64 U25.AL49
M_B_DQSP4: JDIM1.137 U25.AM28
M_B_DQSP5: JDIM1.154 U25.AM25
M_B_DQSP6: JDIM1.171 U25.AM21
M_B_DQSP7: JDIM1.188 U25.AM18
M_B_ODT0: JDIM1.116 R332.2
M_B_ODT1: JDIM1.120 R333.2
M_B_RAS#: JDIM1.110 U25.AM35
M_B_WE#: JDIM1.113 U25.AK35
MAINON: PR106.2 PR113.2 PR124.2 PR129.1 PR169.1 R274.2 U11.33
MBATLED0#: PQ12.2 PQ14.2 U11.25
MBCLK: PC11.1 PD2.1 PR2.2 PR15.2 R190.2 U11.110
MBCLK2: Q38.4 R197.2 U11.115 U16.8
MBCLK3: C387.1 R299.1 U11.94 U13.4
MBDATA: PC10.1 PD1.1 PR1.2 PR13.2 R182.2 U11.111
MBDATA2: Q38.1 R203.2 U11.116 U16.7
MBDATA3: C394.1 R301.1 U11.95 U13.6
MDI0+: U6.11 U8.1
MDI0+_1: CN21.1 U6.6
MDI0-: U6.9 U8.2
MDI0-_1: CN21.2 U6.8
MDI1+: U6.16 U8.4
MDI1+_1: CN21.3 U6.1
MDI1-: U6.14 U8.5
MDI1-_1: CN21.6 U6.3
MDI2+: U7.11 U8.6
MDI2+_1: CN21.4 R124.2 U7.6
MDI2-: U7.9 U8.7
MDI2-_1: CN21.5 R125.2 U7.8
MDI3+: U7.16 U8.9
MDI3+_1: CN21.7 R127.2 U7.1
MDI3-: U7.14 U8.10
MDI3-_1: CN21.8 R128.2 U7.3
MIC_L1: C574.2 U20.28
MIC_R1: C571.2 U20.29
MINICAR_PME#: CN22.1 Q4.1 Q5.1 R96.1
MPHY_PWREN: PQ6.2 R544.1 R545.1 U25.Y2
MS_BS: CN15.10 U19.29
MS_CLK: CN15.9 EC70.1 R402.2
MS_D0: C538.1 CN15.5 R390.2
MS_D1: CN15.7 EC44.1 R377.2
MS_D2: CN15.2 R396.2
MS_D3: CN15.1 EC67.1 R398.2
MUTE_LED_CNTL: Q22.2 R335.1 R431.1
MUTE_LED_CNTL_R: CN13.4 R400.1
MUTE_LED_CNTL_R1: Q22.3 R400.2
MX0: C481.1 CN13.21 U11.58
MX1: C433.1 CN13.32 U11.59
MX2: C456.1 CN13.25 U11.60
MX3: C462.1 CN13.24 U11.61
MX4: C442.1 CN13.28 U11.62
MX5: C443.1 CN13.27 U11.63
MX6: C438.1 CN13.30 U11.64
MX7: C432.1 CN13.31 U11.65
MY0: C455.1 CN13.26 RP3.7 U11.36
MY1: C482.1 CN13.22 RP3.9 U11.37
MY2: C489.1 CN13.20 RP3.1 U11.38
MY3: C497.1 CN13.15 RP4.7 U11.39
MY4: C488.1 CN13.19 RP3.2 U11.40
MY5: C461.1 CN13.23 RP3.8 U11.41
MY6: C496.1 CN13.16 RP4.6 U11.42
MY7: C492.1 CN13.18 RP3.3 U11.43
MY8: C493.1 CN13.17 RP3.4 U11.44
MY9: C451.1 CN13.29 RP3.6 U11.45
MY10: C529.1 CN13.10 RP4.3 U11.46
MY11: C522.1 CN13.11 RP4.2 U11.51
MY12: C498.1 CN13.14 RP4.8 U11.52
MY13: C509.1 CN13.13 RP4.9 U11.53
MY14: C516.1 CN13.12 RP4.1 U11.54
MY15: C539.1 CN13.9 RP4.4 U11.55
MY16: C547.1 CN13.8 R389.2 U11.56
MY17: C552.1 CN13.7 R393.2 U11.57
NB671PG: PR181.1 PU12.2
NBSWON1#: C50.1 CN5.6 R224.2 U11.107
ODD_EJECT#: ODD14.11 ODD15.16 R181.2 R227.2
ODD_PRSNT#_R: R546.1 R553.2 U25.Y1
OVT_DETC: D6.2 Q16.2 R189.1
PCH_DISP_ON: R31.2 U2.3 U25.C6
PCH_DPST_PWM: R27.1 U25.B8
PCH_INVRMEN: R575.2 U25.AV7
PCH_LVDS_BLON: R2.2 U25.A9
PCH_OPI_RCOMP: R583.2 U25.AW15
PCH_SLP_S0_N: R213.2 R283.2 U25.AF3
PCH_SPI1_CLK: R505.2 U25.AA3
PCH_SPI1_CLK_R: C716.1 R225.2 R505.1 TP30.1 U23.6 U24.6
PCH_SPI1_SI: R507.2 U25.AA2
PCH_SPI1_SI_R: R226.2 R507.1 TP28.1 U23.5 U24.5
PCH_SPI1_SO: R489.2 U25.AA4
PCH_SPI1_SO_R: R212.2 R489.1 TP23.1 U23.2 U24.2
PCH_SPI_CS0#: R488.2 U25.Y7
PCH_SPI_CS0#_R: R220.2 R488.1 TP24.1 U23.1 U24.1
PCH_SPI_IO2: R490.2 U25.Y6
PCH_SPI_IO3: R504.1 U25.AF1
PCH_XTAL24_IN: C320.2 R147.2 R209.1
PCH_XTAL24_IN_R: R209.2 U9.5
PCI_SERR#: R527.1 U11.99 U25.V6
PCIE_CLKREQ0#: R534.1 U25.U2
PCIE_CLKREQ1#: R268.1 U25.Y5
PCIE_CLKREQ5#: R158.1 U25.T2
