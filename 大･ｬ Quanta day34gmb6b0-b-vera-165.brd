# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ11: length 57.9
  IN1 w0.076: 131.21,75.78 131.36,75.93 131.36,77.67 132.6,78.92 132.6,82.35 135.52,85.28 135.52,86.44 135.24,86.73 135.24,88.77 135.09,88.92 v2(134.86,88.92)
  IN1 w0.14: v4(129.01,44.45) 129.01,44.15 128.22,43.36 128.07,43.36 127.94,43.49 127.94,43.64 128.29,43.99 128.29,44.37 127.94,44.73 127.94,46.62 125.64,48.92 125.64,51.36 125.07,51.93 125.07,60.63 125.61,61.17 125.61,70.18 131.21,75.78
  BOTTOM w0.076: U25.AK54 135.18,89.25 v2(134.86,88.92)
  BOTTOM w0.127: v4(129.01,44.45) 127.35,46.11 JDIM1.51
M_B_DQ12: length 56.4
  IN1 w0.076: 128.84,77.86 128.84,79.04 130.55,80.76 130.55,82.43 133.32,85.19 133.32,85.91 133.48,86.07 133.48,87.15 133.93,87.6 133.93,88.26 133.91,88.28 v2(133.9,88.28)
  IN1 w0.14: 128.84,77.86 128.7,77.72 128.7,76.67 127.13,75.1 126.51,75.1 122.39,70.99 122.39,48.37 124.01,46.75 124.01,42.37 124.16,42.22 124.48,42.22 124.63,42.37 v4(124.63,42.44)
  BOTTOM w0.076: v2(133.9,88.28) 134.22,88.6 U25.AL55
  BOTTOM w0.127: JDIM1.40 124.05,41.86 v4(124.63,42.44)
M_B_DQ13: length 57.4
  IN1 w0.076: 128.6,77.97 128.63,78 128.63,79.08 130.39,80.83 130.39,82.5 133.16,85.26 133.16,85.98 133.3,86.12 133.3,87.2 133.5,87.41 133.5,88.54 v2(133.9,88.95)
  IN1 w0.14: v4(124.63,40.97) 124.35,40.69 123.77,40.69 123.61,40.84 123.61,46.67 122.05,48.23 122.05,71.13 126.36,75.44 127.13,75.44 128.45,76.76 128.45,77.82 128.6,77.97
  BOTTOM w0.076: v2(133.9,88.95) 134.2,89.25 U25.AK55
  BOTTOM w0.127: v4(124.63,40.97) 124.65,40.95 JDIM1.42
M_B_DQ14: length 54.8
  IN1 w0.076: v2(134.86,85.65) 134.86,85.25 132.17,82.56 132.17,81.9 131.54,81.27 131.54,78.41 130.88,77.76 130.88,76.43 130.64,76.18
  IN1 w0.14: v4(126.63,42.58) 126.96,42.58 127.14,42.39 127.14,42.08 127.26,41.96 127.44,41.96 127.56,42.08 127.56,42.67 127.2,43.02 127.2,46.38 124.39,49.2 124.39,60.91 124.93,61.45 124.93,70.47 130.64,76.18
  BOTTOM w0.076: v2(134.86,85.65) 135.21,86 U25.AR54
  BOTTOM w0.127: v4(126.63,42.58) 127.65,41.56 JDIM1.52
M_B_DQ15: length 56.4
  IN1 w0.076: v2(134.85,87) 134.85,86.86 135.26,86.44 135.26,85.33 132.33,82.4 132.33,81.83 131.7,81.21 131.7,78.34 131.14,77.78 131.14,76.19 130.91,75.96
  IN1 w0.14: v4(126.62,41.07) 126.62,40.67 126.81,40.48 127.68,40.48 127.9,40.71 127.9,42.93 127.6,43.23 127.6,46.47 125.3,48.78 125.3,51.22 124.73,51.79 124.73,60.77 125.27,61.31 125.27,70.33 130.91,75.96
  BOTTOM w0.076: v2(134.85,87) 135.15,87.3 U25.AN54
  BOTTOM w0.127: JDIM1.50 127.05,40.74 126.72,41.07 v4(126.62,41.07)
M_B_DQ16: length 82
  IN1 w0.076: v2(143.49,89.67) 143.49,89.91 141.76,91.64 133.03,91.64 132.79,91.88 130.87,91.88 130.55,91.57 129.56,91.57 129.52,91.62 129.21,91.62
  IN1 w0.14: v4(113.4,40.93) 111.94,42.39 111.94,48.34 112.5,48.9 112.5,72.82 114.83,75.15 114.83,75.46 114.68,75.62 114.35,75.62 114.2,75.76 114.2,75.98 114.35,76.12 114.68,76.12 114.83,76.28 114.83,76.48 114.68,76.63 114.35,76.63 114.2,76.78 114.2,76.99 114.35,77.14 114.68,77.14 114.83,77.29 114.83,79.19 115.48,79.83 115.48,85 120.29,89.81 121.53,89.81 123.13,91.42 125.17,91.42 125.37,91.62 129.21,91.62
  BOTTOM w0.076: U25.AK40 143.81,89.35 v2(143.49,89.67)
  BOTTOM w0.127: JDIM1.4 113.25,40.77 v4(113.4,40.93)
M_B_DQ17: length 81.3
  IN1 w0.076: v2(143.38,88.93) 143.18,89.13 143.18,89.34 143.06,89.46 143.06,90.06 141.64,91.48 132.96,91.48 132.72,91.72 130.94,91.72 130.49,91.27 129.22,91.27
  IN1 w0.14: v4(113.4,42.37) 112.77,42.37 112.28,42.86 112.28,48.18 112.84,48.74 112.84,72.67 115.17,75 115.17,77.99 115.35,78.17 115.7,78.17 115.82,78.29 115.82,78.46 115.59,78.69 115.59,79.07 115.82,79.3 115.82,84.83 120.45,89.46 121.66,89.46 123.28,91.08 124.1,91.08 124.22,90.95 124.22,90.85 124.34,90.73 124.51,90.73 124.64,90.85 124.64,90.95 124.76,91.08 125.32,91.08 125.51,91.27 129.22,91.27
  BOTTOM w0.076: U25.AK42 143.06,89.25 v2(143.38,88.93)
  BOTTOM w0.127: JDIM1.6 113.85,40.56 113.9,40.61 113.9,41.92 113.45,42.37 v4(113.4,42.37)
M_B_DQ18: length 78.7
  IN1 w0.076: 130.48,89.35 130.69,89.56 130.69,89.65 131.66,90.63 132.33,90.63 132.84,90.12 137.87,90.12 138.17,90.42 139.93,90.42 141.13,89.23 141.13,88.69 v2(141.52,88.3)
  IN1 w0.14: 130.48,89.35 129.65,88.53 129.65,87.82 128.96,87.13 128.96,86.79 128.17,86 126.9,86 126.26,85.37 125.22,85.37 124.32,86.27 120.67,86.27 118.16,83.75 118.16,74.68 115.83,72.36 115.83,61.9 115.71,61.78 115.3,61.78 115.18,61.66 115.18,61.48 115.3,61.36 115.71,61.36 115.83,61.24 115.83,61.07 115.71,60.94 115.3,60.94 115.18,60.82 115.18,60.65 115.3,60.52 115.71,60.52 115.83,60.4 115.83,60.23 115.71,60.1 115.3,60.1 115.18,59.98 115.18,59.81 115.3,59.69 115.71,59.69 115.83,59.56 115.83,59.39 115.71,59.27 115.3,59.27 115.18,59.14 115.18,58.97 115.3,58.85 115.71,58.85 115.83,58.72 115.83,58.55 115.71,58.43 115.3,58.43 115.18,58.31 115.18,47.89 116.88,46.2 116.88,45.3 v4(116.26,44.69)
  BOTTOM w0.076: v2(141.52,88.3) 141.67,88.3 U25.AM43
  BOTTOM w0.127: v4(116.26,44.69) 117.15,45.58 JDIM1.17
M_B_DQ19: length 78.3
  IN1 w0.076: v2(140.57,87.68) 140.97,88.08 140.97,89.16 139.88,90.25 138.25,90.25 137.96,89.95 132.75,89.95 132.25,90.46 131.73,90.46 130.91,89.63 130.91,89.42 130.75,89.26
  IN1 w0.14: v4(116.64,42.62) 117.24,43.22 117.24,46.32 115.52,48.04 115.52,57.56 115.68,57.71 116.02,57.71 116.18,57.86 116.18,72.21 118.5,74.54 118.5,83.61 120.82,85.93 124.18,85.93 126.25,83.86 127.48,83.86 127.87,84.25 127.87,84.79 128.6,85.52 128.6,85.78 129.25,86.43 129.25,86.93 129.97,87.64 129.97,88.47 130.75,89.26
  BOTTOM w0.076: U25.AM45 140.78,87.68 v2(140.57,87.68)
  BOTTOM w0.127: JDIM1.18 117.45,41.81 v4(116.64,42.62)
M_B_DQ20: length 78.6
  IN1 w0.076: v2(140.57,88.96) 140.56,88.97 140.56,89.31 139.8,90.07 138.33,90.07 138.05,89.79 132.64,89.79 132.13,90.29 131.8,90.29 131.11,89.6 131.11,89.02
  IN1 w0.14: 131.11,89.02 131.11,88.35 129.55,86.79 129.55,86.31 128.93,85.7 128.93,85.51 128.11,84.69 128.11,83.78 127.77,83.44 126.18,83.44 124.04,85.58 120.96,85.58 118.87,83.5 118.87,74.43 116.52,72.07 116.52,53.48 116.4,53.36 115.99,53.36 115.87,53.23 115.87,53.06 115.99,52.94 116.4,52.94 116.52,52.81 116.52,52.64 116.4,52.52 115.99,52.52 115.87,52.39 115.87,52.22 115.99,52.1 116.4,52.1 116.52,51.98 116.52,51.8 116.4,51.68 115.99,51.68 115.87,51.56 115.87,48.18 117.58,46.47 117.58,41.47 117.2,41.1 v4(116.64,41.1)
  BOTTOM w0.076: v2(140.57,88.96) 140.86,89.25 U25.AK45
  BOTTOM w0.127: v4(116.64,41.1) 116.85,40.89 JDIM1.16
M_B_DQ21: length 80.1
  IN1 w0.076: v2(141.52,88.97) 141.52,89.18 140.1,90.6 138.1,90.6 137.78,90.28 132.91,90.28 132.4,90.79 131.52,90.79 131.34,90.61
  IN1 w0.14: 131.34,90.61 129.35,88.62 129.35,88.39 127.84,86.88 127.84,86.65 127.53,86.35 126.66,86.35 126.06,85.75 125.37,85.75 124.51,86.61 120.53,86.61 117.81,83.89 117.81,74.82 115.49,72.5 115.49,69.91 115.37,69.79 114.96,69.79 114.84,69.67 114.84,69.49 114.96,69.37 115.37,69.37 115.49,69.25 115.49,69.07 115.37,68.95 114.96,68.95 114.84,68.83 114.84,68.66 114.96,68.53 115.37,68.53 115.49,68.41 115.49,68.24 115.37,68.11 114.96,68.11 114.84,67.99 114.84,67.82 114.96,67.69 115.37,67.69 115.49,67.57 115.49,67.4 115.37,67.28 114.96,67.28 114.84,67.15 114.84,66.98 114.96,66.86 115.37,66.86 115.49,66.73 115.49,66.56 115.37,66.44 114.96,66.44 114.84,66.31 114.84,66.14 114.96,66.02 115.37,66.02 115.49,65.9 115.49,65.72 115.37,65.6 114.96,65.6 114.84,65.48 114.84,65.3 114.96,65.18 115.37,65.18 115.49,65.06 115.49,64.88 115.37,64.76 114.96,64.76 114.84,64.64 114.84,64.46 114.96,64.34 115.37,64.34 115.49,64.22 115.49,64.05 115.37,63.92 114.96,63.92 114.84,63.8 114.84,63.63 114.96,63.5 115.37,63.5 115.49,63.38 115.49,63.21 115.37,63.08 114.96,63.08 114.84,62.96 114.84,62.79 114.96,62.67 115.37,62.67 115.49,62.54 115.49,62.37 115.37,62.25 114.96,62.25 114.84,62.12 114.84,47.13 115.79,46.18 v4(116.26,46.18)
  BOTTOM w0.076: U25.AK43 141.8,89.25 v2(141.52,88.97)
  BOTTOM w0.127: JDIM1.15 116.55,46.47 v4(116.26,46.18)
M_B_DQ22: length 80.4
  IN1 w0.076: 130.05,90.97 130.46,90.97 131.05,91.55 132.65,91.55 132.9,91.31 141.53,91.31 142.9,89.94 142.9,89.39 142.99,89.3 142.99,88.04 143.4,87.62 v2(143.37,87.62)
  IN1 w0.14: v4(113.41,44.53) 113.41,44.02 113.26,43.87 112.83,43.87 112.67,44.02 112.67,47.93 113.19,48.44 113.19,72.53 115.52,74.86 115.52,77.5 116.16,78.15 116.16,84.64 120.64,89.12 121.8,89.12 122.92,90.24 129.1,90.24 129.83,90.97 130.05,90.97
  BOTTOM w0.076: v2(143.37,87.62) 143.7,87.95 U25.AM40
  BOTTOM w0.127: v4(113.41,44.53) 112.93,45 112.93,46.09 113.55,46.71 JDIM1.5
M_B_DQ23: length 80.1
  IN1 w0.076: 129.87,90.56 129.97,90.67 130.42,90.67 131.06,91.31 132.66,91.31 132.84,91.14 141.45,91.14 142.73,89.85 142.73,89.25 142.82,89.16 142.82,88.02 v2(142.42,87.62)
  IN1 w0.14: v4(113.39,45.95) 113.13,45.95 113.02,46.06 113.02,46.51 113.17,46.66 113.34,46.66 113.49,46.81 113.49,47.02 113.34,47.17 113.17,47.17 113.02,47.32 113.02,47.76 113.53,48.28 113.53,70.55 113.65,70.67 113.99,70.67 114.11,70.79 114.11,70.97 113.99,71.09 113.65,71.09 113.53,71.21 113.53,71.39 113.65,71.51 114.06,71.51 114.18,71.63 114.18,71.81 114.06,71.93 113.65,71.93 113.53,72.05 113.53,72.23 113.65,72.35 114.05,72.35 114.18,72.48 114.18,73.04 115.86,74.72 115.86,75.51 116.04,75.69 116.38,75.69 116.5,75.81 116.5,75.99 116.38,76.11 115.98,76.11 115.86,76.23 115.86,76.41 115.98,76.53 116.38,76.53 116.5,76.65 116.5,76.83 116.38,76.95 115.98,76.95 115.86,77.07 115.86,77.24 115.98,77.37 116.38,77.37 116.5,77.49 116.5,84.48 120.8,88.77 123.92,88.77 125.04,89.89 129.2,89.89 129.87,90.56
  BOTTOM w0.076: U25.AM42 142.75,87.95 v2(142.42,87.62)
  BOTTOM w0.127: JDIM1.7 114.15,46.58 113.51,45.95 v4(113.39,45.95)
M_B_DQ24: length 61.2
  IN1 w0.076: 135.56,75.5 135.85,75.5 136.17,75.82 136.17,76.51 136.29,76.63 136.65,76.63 136.8,76.78 136.8,77.11 136.65,77.27 136.46,77.27 136.31,77.42 136.31,81.31 136.46,81.46 136.91,81.46 137.06,81.61 137.06,82.58 136.91,82.73 136.7,82.73 136.55,82.88 136.55,83.09 136.7,83.24 136.91,83.24 137.06,83.39 137.06,83.74 137.98,84.66 138.7,84.66 139.39,85.35 139.39,86.29 140.01,86.92 140.01,88.01 139.67,88.35 v2(139.62,88.35)
  IN1 w0.14: 135.56,75.5 133.21,73.16 133.21,71.68 130.13,68.6 130.13,54.27 130.01,54.15 129.65,54.15 129.52,54.03 129.52,53.85 129.65,53.73 130.01,53.73 130.13,53.61 130.13,53.43 130.01,53.31 129.76,53.31 129.64,53.19 129.64,53.01 129.76,52.89 130.01,52.89 130.13,52.77 130.13,49.92 133.08,46.98 133.08,42.93 132.97,42.82 132.76,42.82 132.58,43.01 v4(132.58,43.13)
  BOTTOM w0.076: v2(139.62,88.35) 139.71,88.35 U25.AM46
  BOTTOM w0.127: JDIM1.68 132.45,40.73 131.98,41.2 131.98,43.33 132.13,43.49 132.43,43.49 132.58,43.33 v4(132.58,43.13)
M_B_DQ25: length 60.5
  IN1 w0.076: v2(139.62,89) 140,89 140.18,88.82 140.18,86.85 139.56,86.22 139.56,85.28 138.77,84.49 138.09,84.49 137.31,83.71 137.31,79.81 137.09,79.59 137.09,76.47 136.94,76.31
  IN1 w0.14: 136.94,76.31 133.56,72.93 133.56,71.54 130.48,68.46 130.48,50.06 133.42,47.12 133.42,40.08 133.27,39.93 132.73,39.93 132.58,40.08 v4(132.58,41.61)
  BOTTOM w0.076: U25.AK46 139.89,89 v2(139.62,89)
  BOTTOM w0.127: JDIM1.70 133.05,41.14 v4(132.58,41.61)
M_B_DQ26: length 58.9
  IN1 w0.076: 134.16,77.11 134.16,77.26 134.62,77.72 134.62,82.7 137.31,85.39 137.31,87.6 137.44,87.73 137.58,87.73 v2(137.69,87.62)
  IN1 w0.14: v4(130.34,44.82) 130.52,44.82 130.85,45.15 130.85,46.38 128.14,49.09 128.14,51.67 127.53,52.28 127.53,64.84 128.14,65.45 128.14,70.03 129.51,71.4 130.05,71.4 130.66,72.01 130.66,72.55 131.33,73.22 131.33,73.46 134.16,76.29 134.16,77.11
  BOTTOM w0.076: v2(137.69,87.62) 138.01,87.95 U25.AM49
  BOTTOM w0.127: v4(130.34,44.82) 130.1,44.82 129.94,44.67 129.94,44.27 130.1,44.12 130.6,44.12 130.71,44.01 130.71,43.85 130.6,43.74 130.1,43.74 129.94,43.59 129.94,42.83 129.83,42.72 129.68,42.72 129.56,42.83 129.56,46.03 129.15,46.44 JDIM1.57
M_B_DQ27: length 57.2
  IN1 w0.076: 133.89,77.05 133.89,77.3 134.09,77.5 134.45,77.86 134.45,82.81 137.15,85.51 137.15,87.94 137.29,88.07 137.29,88.6 137.16,88.72 137.16,89.15 137.26,89.26 137.52,89.26 137.71,89.06 v2(137.71,88.92)
  IN1 w0.14: v4(130.35,46.24) 130.35,46.4 127.8,48.95 127.8,51.52 127.17,52.15 127.17,65.29 127.32,65.44 127.64,65.44 127.76,65.57 127.76,65.74 127.64,65.86 127.29,65.86 127.17,65.99 127.17,66.16 127.29,66.28 127.66,66.28 127.79,66.41 127.79,66.58 127.66,66.7 127.29,66.7 127.17,66.82 127.17,67 127.29,67.12 127.63,67.12 127.79,67.27 127.79,67.39 127.63,67.54 127.3,67.54 127.18,67.66 127.18,67.84 127.3,67.96 127.66,67.96 127.79,68.08 127.79,68.26 127.66,68.38 127.3,68.38 127.18,68.5 127.18,68.67 127.3,68.8 127.67,68.8 127.8,68.92 127.8,69.09 127.67,69.22 127.3,69.22 127.18,69.34 127.18,69.52 127.3,69.65 127.66,69.65 127.79,69.77 127.79,70.16 129.37,71.75 129.89,71.75 130.3,72.16 130.3,72.68 130.89,73.26 130.89,73.48 133.89,76.49 133.89,77.05
  BOTTOM w0.076: v2(137.71,88.92) 138.04,89.25 U25.AK49
  BOTTOM w0.127: v4(130.35,46.24) 130.35,46.15 130.22,46.03 130.02,46.03 129.75,46.3 JDIM1.59
M_B_DQ28: length 59.9
  IN1 w0.076: v2(138.67,87.62) 139.06,87.23 139.06,85.48 138.56,84.99 137.78,84.99 136.09,83.3 136.09,81.62 135.82,81.35 135.82,80.2 135.3,79.68 135.3,77.39 135.02,77.11 135.02,76.99
  IN1 w0.14: 135.02,76.99 135.02,75.71 132.53,73.22 132.53,72.29 131.98,71.74 131.98,71.45 130.45,69.93 130.02,69.93 129.45,69.36 129.45,64.42 129.33,64.3 128.96,64.3 128.84,64.18 128.84,64 128.96,63.88 129.33,63.88 129.45,63.76 129.45,63.59 129.33,63.46 128.96,63.46 128.84,63.34 128.84,63.17 128.96,63.04 129.33,63.04 129.45,62.92 129.45,62.75 129.33,62.62 128.96,62.62 128.84,62.5 128.84,62.33 128.96,62.21 129.33,62.21 129.45,62.08 129.45,61.91 129.33,61.79 128.96,61.79 128.84,61.66 128.84,61.49 128.96,61.37 129.33,61.37 129.45,61.24 129.45,61.07 129.33,60.95 128.96,60.95 128.84,60.83 128.84,52.85 129.45,52.24 129.45,49.64 132.17,46.91 132.17,44.61 131.98,44.42 131.98,43.78 132.16,43.61 132.43,43.61 132.62,43.8 v4(132.62,44.65)
  BOTTOM w0.076: U25.AM48 138.99,87.95 v2(138.67,87.62)
  BOTTOM w0.127: v4(132.62,44.65) 132.65,44.65 133.13,45.13 133.13,46.19 132.75,46.57 JDIM1.69
M_B_DQ29: length 59.2
  IN1 w0.076: 135.38,76.99 136.09,77.7 136.09,81.39 136.25,81.55 136.25,81.97 136.38,82.09 136.69,82.09 136.8,82.2 136.8,82.36 136.69,82.47 136.38,82.47 136.25,82.6 136.25,83.19 137.88,84.82 138.63,84.82 139.23,85.41 139.23,88.37 v2(138.67,88.93)
  IN1 w0.14: 135.38,76.99 135.27,76.87 135.27,75.61 132.87,73.22 132.87,72.15 132.36,71.63 132.36,71.34 130.54,69.52 130.25,69.52 129.79,69.07 129.79,60.6 129.67,60.48 129.3,60.48 129.18,60.36 129.18,60.19 129.3,60.06 129.67,60.06 129.79,59.94 129.79,59.77 129.67,59.64 129.3,59.64 129.18,59.52 129.18,59.35 129.3,59.22 129.67,59.22 129.79,59.1 129.79,58.93 129.67,58.81 129.3,58.81 129.18,58.68 129.18,58.51 129.3,58.39 129.67,58.39 129.79,58.26 129.79,58.09 129.67,57.97 129.3,57.97 129.18,57.84 129.18,57.67 129.3,57.55 129.67,57.55 129.79,57.43 129.79,57.25 129.67,57.13 129.3,57.13 129.18,57.01 129.18,56.83 129.3,56.71 129.67,56.71 129.79,56.59 129.79,56.41 129.67,56.29 129.3,56.29 129.18,56.17 129.18,55.99 129.3,55.87 129.67,55.87 129.79,55.75 129.79,55.58 129.67,55.45 129.3,55.45 129.18,55.33 129.18,55.16 129.3,55.03 129.67,55.03 129.79,54.91 129.79,54.74 129.67,54.61 129.3,54.61 129.18,54.49 129.18,52.99 129.79,52.38 129.79,49.78 132.71,46.86 132.71,46.16 v4(132.62,46.08)
  BOTTOM w0.076: v2(138.67,88.93) 138.99,89.25 U25.AK48
  BOTTOM w0.127: JDIM1.67 132.15,46.55 v4(132.62,46.08)
M_B_DQ30: length 57.1
  IN1 w0.076: v2(136.74,87.61) 136.36,87.23 136.36,86.67 136.26,86.57 136.26,84.96 134.18,82.88 134.18,82.7
  IN1 w0.14: v4(129.01,42.67) 129.28,42.67 129.46,42.49 129.46,41.81 129.58,41.68 129.75,41.68 129.88,41.81 129.88,46.39 127.45,48.81 127.45,51.38 126.82,52.02 126.82,69.68 130.55,73.41 130.55,73.56 133.58,76.58 133.58,80.68 134.18,81.29 134.18,82.7
  BOTTOM w0.076: U25.AM51 137.07,87.95 v2(136.74,87.61)
  BOTTOM w0.127: JDIM1.56 128.85,40.59 128.37,41.07 128.37,42.04 v4(129.01,42.67)
M_B_DQ31: length 56.3
  IN1 w0.076: v2(136.74,88.92) 136.32,88.5 136.32,88.06 136.19,87.94 136.19,86.74 136.01,86.56 136.01,85.08 133.9,82.96 133.9,82.63
  IN1 w0.14: 133.9,82.63 133.9,81.43 133.25,80.79 133.25,76.6 126.48,69.83 126.48,51.75 127.11,51.11 127.11,48.67 129.53,46.25 129.53,43.9 128.55,42.92 128.55,41.66 v4(129.01,41.2)
  BOTTOM w0.076: v2(136.74,88.92) 137.07,89.25 U25.AK51
  BOTTOM w0.127: v4(129.01,41.2) 129.45,40.76 JDIM1.58
M_B_DQ32: length 55.6
  IN1 w0.076: v2(150.16,88.27) 150.16,88.42 150.01,88.57 149.6,88.57 149.44,88.42 149.44,85.32 148.54,84.41 148.54,83.52 148.41,83.39 148.41,78.08 148.98,77.51 149.03,77.45 149.03,74.96 149.41,74.58 149.67,74.58
  IN1 w0.14: 149.67,74.58 149.76,74.58 152.03,72.31 152.03,68.39 156.01,64.41 156.01,54.3 154.5,52.79 154.5,52.22 154.3,52.02 153.91,52.02 153.75,51.86 153.75,49.05 153.87,48.93 154.38,48.93 154.5,48.8 154.5,48.63 154.38,48.51 153.87,48.51 153.75,48.39 153.75,48.21 153.87,48.09 154.38,48.09 154.5,47.97 154.5,47.6 154.26,47.36 154.05,47.36 153.74,47.67 153.48,47.67 153.36,47.55 153.36,47.37 153.59,47.14 153.59,46.86 153.11,46.38 153.11,45.85 v4(153.22,45.75)
  BOTTOM w0.076: U25.AM29 150.49,87.95 v2(150.16,88.27)
  BOTTOM w0.127: JDIM1.129 153.15,46.43 153,46.28 152.7,46.28 152.55,46.13 152.55,45.9 152.7,45.75 v4(153.22,45.75)
M_B_DQ33: length 57.5
  IN1 w0.076: v2(150.12,89.67) 150.12,89.69 149.97,89.84 149.42,89.84 149.27,89.69 149.27,85.39 148.36,84.48 148.36,83.59 148.23,83.46 148.23,77.25 148.87,76.62 148.87,74.89 149.45,74.32 149.59,74.32
  IN1 w0.14: v4(153.22,44.25) 153.06,44.25 152.77,44.54 152.77,47.44 153.41,48.08 153.41,52.2 155.66,54.46 155.66,64.27 151.69,68.24 151.69,72.31 149.68,74.32 149.59,74.32
  BOTTOM w0.076: v2(150.12,89.67) 150.55,89.25 U25.AK29
  BOTTOM w0.127: v4(153.22,44.25) 153.22,43.76 153.37,43.61 153.8,43.61 153.95,43.76 153.95,45.77 153.75,45.97 JDIM1.131
M_B_DQ34: length 56.2
  IN1 w0.076: v2(151.05,88.93) 151.46,88.53 151.46,88.06 151.51,88.01 151.51,83.64 151.03,83.16 151.03,81.71 151.41,81.33 151.41,78.66 151.92,78.16 151.92,77.66 151.36,77.11 151.36,75.4 152.42,74.34 153.07,74.34 153.24,74.17
  IN1 w0.14: 153.24,74.17 154.71,72.7 154.71,69.5 158.68,65.52 158.68,62.67 158.85,62.5 159.09,62.5 159.45,62.15 159.45,53.95 157.5,52 157.5,51.61 157.74,51.38 157.74,47.53 157.18,46.97 157.18,44.02 157.03,43.87 156.71,43.87 156.56,44.02 v4(156.56,44.53)
  BOTTOM w0.076: v2(151.05,88.93) 151.17,88.93 U25.AL28
  BOTTOM w0.127: JDIM1.143 157.35,46.34 157.16,46.15 157.16,45.14 v4(156.56,44.53)
M_B_DQ35: length 56.3
  IN1 w0.076: 153.45,74.38 153.33,74.5 153.33,74.96 152.25,76.05 152.25,78.46 151.61,79.1 151.61,81.51 151.28,81.84 151.28,83.08 151.67,83.48 151.67,88.08 151.65,88.11 151.65,88.59 v2(152.02,88.96)
  IN1 w0.14: 153.45,74.38 155.05,72.78 155.05,69.64 159.03,65.67 159.03,63.05 159.79,62.29 159.79,53.81 158.6,52.61 158.6,52.21 158.1,51.72 158.1,47.4 157.52,46.82 157.52,43.76 157,43.23 157,40.95 156.87,40.82 156.51,40.82 v4(156.23,41.1)
  BOTTOM w0.076: U25.AK28 151.73,89.25 v2(152.02,88.96)
  BOTTOM w0.127: JDIM1.140 156.45,40.87 v4(156.23,41.1)
M_B_DQ36: length 53.9
  IN1 w0.076: 151.52,73.51 150.05,74.98 150.05,77.28 148.77,78.56 148.77,83.24 148.89,83.37 148.89,84.26 149.8,85.17 149.8,85.96 v2(150.16,86.32)
  IN1 w0.14: v4(153.51,41.12) 153.66,40.97 153.86,40.97 154.01,41.12 154.01,46.14 155.19,47.31 155.19,52.51 156.69,54.01 156.69,55.11 156.81,55.23 157.26,55.23 157.42,55.39 157.42,56.85 156.69,57.58 156.69,64.7 152.72,68.67 152.72,72.31 151.52,73.51
  BOTTOM w0.076: v2(150.16,86.32) 150.49,86 U25.AR29
  BOTTOM w0.127: JDIM1.130 153.45,41.06 v4(153.51,41.12)
M_B_DQ37: length 55.6
  IN1 w0.076: v2(150.16,87.62) 149.62,87.08 149.62,85.24 148.72,84.34 148.72,83.44 148.59,83.32 148.59,78.21 149.2,77.6 149.2,75.05 149.45,74.8 149.88,74.8
  IN1 w0.14: v4(153.51,42.54) 153.67,42.7 153.67,46.28 154.84,47.45 154.84,52.65 156.35,54.15 156.35,55.31 156.61,55.58 156.61,55.85 156.35,56.12 156.35,56.29 156.47,56.41 156.96,56.41 157.08,56.53 157.08,56.71 156.96,56.83 156.5,56.83 156.35,56.98 156.35,64.55 152.37,68.53 152.37,72.31 149.88,74.8
  BOTTOM w0.076: U25.AN29 150.49,87.3 v2(150.16,87.62)
  BOTTOM w0.127: JDIM1.132 154.05,42 v4(153.51,42.54)
M_B_DQ38: length 53.8
  IN1 w0.076: v2(151.11,85.66) 151.11,84.7 150.66,84.24 150.66,81.57 151.23,81 151.23,78.28 151.33,78.19 151.33,77.42 151.17,77.26 151.17,75.31 152.3,74.18 152.77,74.18 153.01,73.94
  IN1 w0.14: 153.01,73.94 154.37,72.58 154.37,69.36 158.34,65.38 158.34,62.28 158.46,62.16 158.95,62.16 159.07,62.04 159.07,61.87 158.95,61.74 158.46,61.74 158.34,61.62 158.34,61.45 158.46,61.32 158.95,61.32 159.07,61.2 159.07,61.03 158.95,60.9 158.46,60.9 158.34,60.78 158.34,60.61 158.46,60.49 158.95,60.49 159.07,60.36 159.07,60.19 158.95,60.07 158.46,60.07 158.34,59.94 158.34,59.77 158.46,59.65 158.95,59.65 159.07,59.52 159.07,59.35 158.95,59.23 158.46,59.23 158.34,59.11 158.34,58.93 158.46,58.81 158.95,58.81 159.07,58.69 159.07,58.51 158.95,58.39 158.64,58.39 158.51,58.27 158.51,58.09 158.64,57.97 158.95,57.97 159.11,57.81 159.11,54.09 156.84,51.82 156.84,48.94 156.96,48.81 157.27,48.81 157.4,48.69 157.4,48.52 157.27,48.39 156.96,48.39 156.84,48.27 156.84,46.31 v4(156.51,45.98)
  BOTTOM w0.076: U25.AR28 151.45,86 v2(151.11,85.66)
  BOTTOM w0.127: JDIM1.141 156.75,46.22 v4(156.51,45.98)
M_B_DQ39: length 54.7
  IN1 w0.076: 152.43,73.98 152.24,73.98 150.93,75.29 150.93,77.42 150.29,78.06 150.29,84.3 150.49,84.51 150.49,85.61 151.11,86.23 v2(151.11,86.32)
  IN1 w0.14: v4(156.23,42.75) 155.64,42.16 155.53,42.16 155.3,42.39 155.3,42.61 155.93,43.23 155.93,46.2 156.49,46.77 156.49,51.96 158.73,54.2 158.73,57.39 158,58.12 158,65.24 154.02,69.21 154.02,72.39 152.43,73.98
  BOTTOM w0.076: U25.AP28 151.18,86.32 v2(151.11,86.32)
  BOTTOM w0.127: v4(156.23,42.75) 157.05,41.92 JDIM1.142
M_B_DQ40: length 55.8
  IN1 w0.076: v2(152.07,86.97) 152.48,86.56 152.48,86.08 152.14,85.74 152.14,82.85 152.81,82.19 152.81,79.06 152.74,78.99 152.74,76.07 153.9,74.92 153.9,74.63 154.06,74.47
  IN1 w0.14: v4(158.59,46.24) 158.59,46.67 158.97,47.05 158.97,47.52 159.09,47.64 159.56,47.64 159.68,47.76 159.68,47.94 159.56,48.06 159.09,48.06 158.97,48.18 158.97,48.36 159.09,48.48 159.74,48.48 159.87,48.6 159.87,48.78 159.74,48.9 159.09,48.9 158.97,49.03 158.97,51.36 159.46,51.85 159.46,52.25 160.66,53.45 160.66,63.21 160.53,63.33 160.12,63.33 160,63.45 160,63.63 160.12,63.75 160.53,63.75 160.66,63.87 160.66,64.05 160.53,64.17 160.12,64.17 160,64.29 160,64.46 160.12,64.59 160.53,64.59 160.66,64.71 160.66,64.88 160.53,65.01 160.12,65.01 160,65.13 160,65.92 155.92,70 155.92,72.62 154.06,74.47
  BOTTOM w0.076: U25.AN26 152.39,87.3 v2(152.07,86.97)
  BOTTOM w0.127: v4(158.59,46.24) 158.13,45.79 158.13,45.04 158.02,44.92 157.86,44.92 157.75,45.04 157.75,46.02 158.55,46.81 JDIM1.147
M_B_DQ41: length 54.7
  IN1 w0.076: v2(152.07,86.32) 152.07,86 151.97,85.9 151.97,82.79 152.64,82.12 152.64,79.13 152.51,79 152.51,76.03 153.65,74.89 153.65,74.54 153.72,74.47
  IN1 w0.14: v4(158.16,41.08) 158.12,41.04 158.12,40.16 157.97,40 157.71,40 157.56,40.16 157.56,42.99 158.14,43.57 158.14,46.7 158.62,47.19 158.62,51.5 159.12,51.99 159.12,52.39 160.31,53.59 160.31,62.65 159.55,63.42 159.55,65.88 155.57,69.86 155.57,72.62 153.72,74.47
  BOTTOM w0.076: v2(152.07,86.32) 152.39,86 U25.AR26
  BOTTOM w0.127: JDIM1.146 158.25,40.99 v4(158.16,41.08)
M_B_DQ42: length 54.2
  IN1 w0.076: 154.74,74.47 154.38,74.83 154.38,75 153.59,75.79 153.59,77.22 153.72,77.35 153.72,79.43 153.14,80.01 153.14,82.78 152.84,83.08 v2(152.84,85.63)
  IN1 w0.14: 154.74,74.47 156.6,72.61 156.6,70.28 161.34,65.54 161.34,53.16 160.55,52.37 160.55,47.66 159.57,46.68 159.57,45 158.8,44.23 158.8,42.57 159.14,42.23 159.14,42.01 159.02,41.88 158.88,41.88 158.16,42.61 v4(158.16,42.74)
  BOTTOM w0.076: v2(152.84,85.63) 153.21,86 U25.AR25
  BOTTOM w0.127: JDIM1.148 158.85,42.04 v4(158.16,42.74)
M_B_DQ43: length 55.3
  IN1 w0.076: 154.4,74.47 154.13,74.75 154.13,74.97 152.91,76.19 152.91,78.93 152.97,78.99 152.97,82.48 152.39,83.07 152.39,85.73 152.87,86.22 v2(152.87,86.32)
  IN1 w0.14: 154.4,74.47 156.26,72.61 156.26,70.14 161,65.4 161,53.31 160.35,52.66 159.99,52.29 159.99,51.51 159.82,51.34 159.56,51.34 159.44,51.22 159.44,51.04 159.56,50.92 160.09,50.92 160.21,50.8 160.21,50.62 160.09,50.5 159.43,50.5 159.31,50.38 159.31,50.2 159.43,50.08 160.09,50.08 160.21,49.96 160.21,49.78 160.09,49.66 159.43,49.66 159.31,49.54 159.31,49.37 159.43,49.24 160.09,49.24 160.21,49.12 160.21,47.81 159.23,46.83 159.23,45.44 v4(158.61,44.82)
  BOTTOM w0.076: U25.AP25 153.2,86.65 v2(152.87,86.32)
  BOTTOM w0.127: JDIM1.149 159.15,44.48 159,44.33 158.77,44.33 158.61,44.48 v4(158.61,44.82)
M_B_DQ44: length 57.3
  IN1 w0.076: 157.48,74.47 156.3,75.64 156.3,77.31 155.67,77.93 155.67,82.27 154.09,83.85 154.09,88.49 154.21,88.61 154.21,89.08 153.63,89.66 v2(152.84,89.66)
  IN1 w0.14: 157.48,74.47 158.94,73.01 158.94,71.25 163.68,66.51 163.68,47.34 162.66,46.32 162.66,42.16 161.48,40.98 v4(161.33,40.98)
  BOTTOM w0.076: v2(152.84,89.66) 152.46,89.27 U25.AK26
  BOTTOM w0.127: v4(161.33,40.98) 161.66,40.98 161.85,40.79 JDIM1.158
M_B_DQ45: length 57.3
  IN1 w0.076: 154.31,75.87 154.13,76.06 154.13,76.94 154.34,77.15 154.34,82.78 153.6,83.53 153.6,88.13 153.09,88.64 152.64,88.64 152.45,88.44 152.45,88.01 v2(152.07,87.62)
  IN1 w0.14: v4(161.34,42.41) 160.88,42.88 160.88,46.14 161.86,47.12 161.86,51.83 162.65,52.62 162.65,66.09 157.91,70.83 157.91,72.9 156.77,74.04 156.14,74.04 154.31,75.87
  BOTTOM w0.076: v2(152.07,87.62) 152.39,87.95 U25.AM26
  BOTTOM w0.127: JDIM1.160 162.45,41.31 v4(161.34,42.41)
M_B_DQ46: length 57.3
  IN1 w0.076: 156.96,74.66 156.9,74.72 156.9,74.79 154.89,76.81 154.89,79.86 155.44,80.41 155.44,82.27 153.93,83.78 153.93,88.8 v2(153.82,88.91)
  IN1 w0.14: v4(161.33,44.43) 161.69,44.07 161.69,42.92 161.82,42.79 162.18,42.79 162.32,42.93 162.32,46.46 163.34,47.48 163.34,66.37 158.6,71.11 158.6,73.03 156.96,74.66
  BOTTOM w0.076: v2(153.82,88.91) 153.48,89.25 U25.AK25
  BOTTOM w0.127: v4(161.33,44.43) 162.15,45.25 JDIM1.159
M_B_DQ47: length 57.4
  IN1 w0.076: 157.1,74.2 156.71,74.59 156.71,74.75 154.64,76.82 154.64,80 154.51,80.13 154.51,82.86 153.76,83.6 153.76,88.35 153.08,89.03 v2(152.94,89.03)
  IN1 w0.14: 157.1,74.2 158.25,73.05 158.25,70.97 162.99,66.23 162.99,52.13 162.84,51.97 162.49,51.97 162.36,51.85 162.36,51.68 162.49,51.55 162.87,51.55 162.99,51.43 162.99,51.26 162.87,51.13 162.38,51.13 162.2,50.95 162.2,49.08 162.33,48.95 162.87,48.95 162.99,48.83 162.99,48.66 162.87,48.53 162.33,48.53 162.2,48.41 162.2,48.24 162.33,48.11 162.87,48.11 162.99,47.99 162.99,47.82 162.87,47.7 162.33,47.7 162.2,47.57 162.2,46.95 161.97,46.72 161.97,45.56 161.87,45.46 161.7,45.46 161.57,45.6 161.57,45.82 161.43,45.96 v4(161.33,45.96)
  BOTTOM w0.076: v2(152.94,89.03) 153.37,88.6 U25.AL25
  BOTTOM w0.127: v4(161.33,45.96) 161.15,45.77 160.57,45.77 160.44,45.9 160.44,46.25 160.56,46.37 161.4,46.37 161.55,46.53 JDIM1.157
M_B_DQ48: length 52.8
  IN1 w0.076: v2(156.62,85.64) 156.62,84.86 156.92,84.56 159.28,82.2 159.28,79.5 159.76,79.02 159.76,78.92
  IN1 w0.14: 159.76,78.92 159.76,77.21 161.14,75.83 161.14,74.75 162.88,73.02 162.88,72.81 167.56,68.12 167.56,65.97 167.69,65.85 167.97,65.85 168.09,65.73 168.09,65.55 167.97,65.43 167.69,65.43 167.56,65.31 167.56,65.13 167.69,65.01 167.97,65.01 168.09,64.89 168.09,64.71 167.97,64.59 167.69,64.59 167.56,64.47 167.56,64.29 167.69,64.17 167.97,64.17 168.09,64.05 168.09,51.49 168.65,50.94 168.65,48.86 168.53,48.74 168.22,48.74 168.09,48.61 168.09,48.44 168.22,48.32 168.53,48.32 168.65,48.2 168.65,48.02 168.53,47.9 168.22,47.9 168.09,47.78 168.09,47.6 168.22,47.48 168.53,47.48 168.65,47.36 168.65,47.18 168.53,47.06 168.22,47.06 168.09,46.94 168.09,46.76 168.22,46.64 168.53,46.64 168.65,46.52 168.65,46.35 168.53,46.22 168.25,46.22 168.09,46.07 168.09,45.94 v4(168.23,45.8)
  BOTTOM w0.076: v2(156.62,85.64) 156.26,86 U25.AR21
  BOTTOM w0.127: v4(168.23,45.8) 168.08,45.64 167.69,45.64 167.55,45.78 JDIM1.177
M_B_DQ49: length 53.4
  IN1 w0.076: 160.2,73.03 160.2,73.46 156.83,76.83 156.83,79.31 156.21,79.93 156.21,82.5 154.83,83.89 v2(154.83,85.66)
  IN1 w0.14: v4(164.61,42.32) 164.26,42.32 163.52,43.05 163.52,44.66 164.37,45.51 164.71,45.51 164.93,45.73 164.93,46.17 165.4,46.64 165.4,47.15 164.93,47.62 164.93,51.34 165.26,51.67 165.26,60.74 164.89,61.12 164.89,67.01 160.2,71.7 160.2,73.03
  BOTTOM w0.076: U25.AR22 155.16,86 v2(154.83,85.66)
  BOTTOM w0.127: v4(164.61,42.32) 163.65,41.36 JDIM1.164
M_B_DQ50: length 55.5
  IN1 w0.076: 159.1,78.92 159.1,78.97 158.92,79.16 158.92,81.57 156.93,83.56 156.93,84.09 156.03,84.98 156.03,85.86 156.15,85.98 156.15,87.88 v2(155.76,88.27)
  IN1 w0.14: v4(165.89,40.86) 167.41,42.38 167.41,61.48 166.88,62.01 166.88,67.84 162.19,72.53 162.19,73.02 160.22,74.99 160.22,75.87 159.1,76.99 159.1,78.92
  BOTTOM w0.076: v2(155.76,88.27) 156.09,88.6 U25.AL21
  BOTTOM w0.127: v4(165.89,40.86) 166.35,40.86 166.65,40.56 JDIM1.174
M_B_DQ51: length 55.7
  IN1 w0.076: 159.85,73.35 159.85,73.57 156.67,76.76 156.67,79.24 156.01,79.9 156.01,82.47 154.42,84.06 154.42,87.24 v2(154.79,87.61)
  IN1 w0.14: v4(164.48,46.03) 164.4,46.03 163.93,45.56 163.7,45.56 163.52,45.73 163.52,45.96 164.27,46.71 164.94,46.71 165.06,46.83 165.06,47.01 164.94,47.13 164.66,47.13 164.54,47.25 164.54,51.62 164.76,51.83 164.76,52.13 164.54,52.34 164.54,52.68 164.67,52.81 164.79,52.81 164.92,52.93 164.92,53.16 164.79,53.29 164.67,53.29 164.54,53.42 164.54,53.66 164.67,53.78 164.8,53.78 164.92,53.91 164.92,54.08 164.8,54.2 164.66,54.2 164.54,54.33 164.54,54.5 164.66,54.62 164.8,54.62 164.92,54.75 164.92,54.92 164.8,55.04 164.66,55.04 164.54,55.16 164.54,55.34 164.66,55.46 164.8,55.46 164.92,55.58 164.92,55.76 164.8,55.88 164.66,55.88 164.54,56 164.54,56.18 164.66,56.3 164.8,56.3 164.92,56.42 164.92,56.6 164.8,56.72 164.66,56.72 164.54,56.84 164.54,57.01 164.66,57.14 164.8,57.14 164.92,57.26 164.92,57.43 164.8,57.56 164.66,57.56 164.54,57.68 164.54,57.85 164.66,57.98 164.8,57.98 164.92,58.1 164.92,58.27 164.8,58.39 164.66,58.39 164.54,58.52 164.54,58.69 164.66,58.81 164.8,58.81 164.92,58.94 164.92,59.11 164.8,59.23 164.66,59.23 164.54,59.36 164.54,59.53 164.66,59.65 164.8,59.65 164.92,59.77 164.92,59.95 164.8,60.07 164.68,60.07 164.54,60.21 164.54,66.87 159.85,71.56 159.85,73.35
  BOTTOM w0.076: v2(154.79,87.61) 155.13,87.95 U25.AM22
  BOTTOM w0.127: JDIM1.165 163.95,46.44 164.36,46.03 v4(164.48,46.03)
M_B_DQ52: length 54.5
  IN1 w0.076: 160.54,73.1 160.54,73.35 157,76.89 157,81.53 156.37,82.15 156.37,82.61 155.24,83.74 155.24,85.81 154.82,86.23 v2(154.82,86.97)
  IN1 w0.14: 160.54,73.1 160.54,71.84 165.23,67.16 165.23,61.26 165.76,60.73 165.76,51.68 165.28,51.2 165.28,48.78 165.76,48.3 165.76,46.51 165.28,46.02 165.28,45.59 165.07,45.38 165.07,43.51 164.95,43.38 164.61,43.38 164.48,43.51 v4(164.48,44.12)
  BOTTOM w0.076: U25.AN22 155.14,87.3 v2(154.82,86.97)
  BOTTOM w0.127: JDIM1.163 163.35,45.25 v4(164.48,44.12)
M_B_DQ53: length 53.4
  IN1 w0.076: v2(155.75,86.32) 155.84,86.23 155.84,84.94 156.75,84.03 156.75,83.5 158.75,81.5 158.75,78.92
  IN1 w0.14: 158.75,78.92 158.75,76.99 159.82,75.92 159.82,75.05 161.85,73.02 161.85,72.39 166.54,67.7 166.54,61.87 167.07,61.34 167.07,44.32 166.52,43.77 166.52,42.49 166.31,42.28 v4(165.89,42.28)
  BOTTOM w0.076: v2(155.75,86.32) 156.08,86.65 U25.AP21
  BOTTOM w0.127: v4(165.89,42.28) 167.25,40.92 JDIM1.176
M_B_DQ54: length 56.1
  IN1 w0.076: 159.41,78.92 159.41,78.97 159.08,79.3 159.08,81.64 157.09,83.62 157.09,84.15 156.21,85.04 156.21,85.8 156.32,85.91 156.32,88.37 v2(155.76,88.93)
  IN1 w0.14: v4(168.23,44.25) 167.75,44.74 167.75,61.91 167.63,62.03 167.34,62.03 167.22,62.15 167.22,62.33 167.34,62.45 167.63,62.45 167.75,62.57 167.75,62.75 167.63,62.87 167.34,62.87 167.22,62.99 167.22,63.16 167.34,63.29 167.63,63.29 167.75,63.41 167.75,63.58 167.63,63.71 167.34,63.71 167.22,63.83 167.22,67.98 162.53,72.67 162.53,73.02 160.83,74.72 160.83,75.8 159.41,77.23 159.41,78.92
  BOTTOM w0.076: U25.AK21 156.09,89.25 v2(155.76,88.93)
  BOTTOM w0.127: v4(168.23,44.25) 166.95,45.54 JDIM1.175
M_B_DQ55: length 56.5
  IN1 w0.076: v2(154.83,88.95) 154.26,88.39 154.26,83.92 155.84,82.34 155.84,78.06 156.5,77.4 156.5,75.73 157.76,74.47 158.09,74.47
  IN1 w0.14: 158.09,74.47 158.17,74.47 159.46,73.18 159.46,71.47 164.2,66.73 164.2,47.12 163.18,46.1 163.18,41.19 163.47,40.89 v4(164.6,40.89)
  BOTTOM w0.076: U25.AK22 155.12,89.25 v2(154.83,88.95)
  BOTTOM w0.127: JDIM1.166 164.25,40.54 v4(164.6,40.89)
M_B_DQ56: length 57.7
  IN1 w0.076: 159.31,82.77 159.18,82.77 157.25,84.7 157.25,87.09 v2(156.72,87.62)
  IN1 w0.14: v4(168.23,41.1) 168.04,40.91 168.04,40.18 168.33,39.9 169.14,39.9 169.29,40.05 169.29,45.7 169.52,45.92 169.52,51.29 168.96,51.85 168.96,68.14 163.22,73.88 163.22,74.44 160.25,77.41 160.25,79.1 159.65,79.7 159.65,82.44 159.31,82.77
  BOTTOM w0.076: U25.AN20 157.04,87.3 v2(156.72,87.62)
  BOTTOM w0.127: v4(168.23,41.1) 168.45,40.88 JDIM1.180
M_B_DQ57: length 56.8
  IN1 w0.076: v2(156.72,86.32) 157.08,85.95 157.08,84.63 159.13,82.59 159.45,82.27 159.45,79.62 160.01,79.07 160.01,78.92
  IN1 w0.14: 160.01,78.92 160.01,77.31 162.88,74.44 162.88,73.55 168.09,68.34 168.09,68.16 168.23,68.02 168.5,68.02 168.62,67.91 168.62,67.73 168.49,67.6 168.21,67.6 168.09,67.48 168.09,67.31 168.21,67.18 168.49,67.18 168.62,67.06 168.62,66.89 168.49,66.76 168.21,66.76 168.09,66.64 168.09,66.47 168.21,66.35 168.49,66.35 168.62,66.22 168.62,51.71 169.17,51.15 169.17,46.06 168.95,45.84 168.95,42.24 168.83,42.11 168.66,42.11 168.53,42.24 168.53,42.6 168.39,42.75 v4(168.23,42.75)
  BOTTOM w0.076: v2(156.72,86.32) 157.04,86 U25.AR20
  BOTTOM w0.127: JDIM1.182 169.05,42.48 168.78,42.75 v4(168.23,42.75)
M_B_DQ58: length 59
  IN1 w0.076: 161,84.07 160.76,84.31 160.76,84.97 159.82,85.92 159.82,88.65 159.26,89.21 158.81,89.21 v2(158.51,89.51)
  IN1 w0.14: v4(172.04,42.36) 172.43,42.36 172.69,42.62 172.69,43.66 173.38,44.35 173.38,49.78 173.91,50.32 173.91,53.38 173.38,53.92 173.38,56.34 172.59,57.12 172.59,62.88 171.98,63.49 171.98,69.55 162.58,78.95 162.58,82.49 161,84.07
  BOTTOM w0.076: v2(158.51,89.51) 158.25,89.25 U25.AK18
  BOTTOM w0.127: v4(172.04,42.36) 172.6,42.36 172.87,42.09 172.87,41.71 172.65,41.49 JDIM1.194
M_B_DQ59: length 58.3
  IN1 w0.076: 160.77,83.1 160.07,83.8 160.07,84.72 159.86,84.93 159.35,84.93 159.23,84.81 159.23,84.52 159.12,84.4 158.97,84.4 158.85,84.53 158.85,84.81 158.69,84.97 158.69,87.39 157.83,88.24 v2(157.56,88.24)
  IN1 w0.14: 160.77,83.1 161.03,82.83 161.03,80.32 161.8,79.55 161.8,78.28 170.95,69.12 170.95,63.07 171.51,62.51 171.51,56.26 171.63,56.14 172.05,56.14 172.18,56.01 172.18,55.84 172.05,55.72 171.63,55.72 171.51,55.6 171.51,55.42 171.63,55.3 172.06,55.3 172.18,55.18 172.18,55 172.06,54.88 171.63,54.88 171.51,54.76 171.51,54.58 171.63,54.46 172.06,54.46 172.18,54.34 172.18,54.16 172.06,54.04 171.63,54.04 171.51,53.92 171.51,53.74 171.63,53.62 172.06,53.62 172.18,53.5 172.18,53.33 172.06,53.2 171.63,53.2 171.51,53.08 171.51,52.91 171.63,52.78 172.06,52.78 172.18,52.66 172.18,52.49 172.06,52.36 171.63,52.36 171.51,52.24 171.51,52.07 171.63,51.95 172.04,51.95 172.17,51.82 172.17,46.32 v4(172.08,46.23)
  BOTTOM w0.076: U25.AL18 157.89,88.77 157.63,88.77 157.45,88.6 157.45,88.36 v2(157.56,88.24)
  BOTTOM w0.127: JDIM1.191 171.75,46.78 171.55,46.58 171.55,46.36 171.68,46.23 v4(172.08,46.23)
M_B_DQ60: length 59.4
  IN1 w0.076: 161.47,83.04 160.58,83.94 160.58,84.93 159.65,85.85 159.65,88.58 159.2,89.03 158.17,89.03 v2(157.65,89.55)
  IN1 w0.14: 161.47,83.04 162.28,82.23 162.28,78.77 171.64,69.41 171.64,63.35 172.24,62.75 172.24,56.97 173.02,56.19 173.02,53.27 173.15,53.15 173.42,53.15 173.54,53.02 173.54,52.85 173.42,52.73 173.15,52.73 173.02,52.6 173.02,52.43 173.15,52.31 173.42,52.31 173.54,52.18 173.54,52.01 173.42,51.89 173.15,51.89 173.02,51.77 173.02,44.54 172.6,44.12 172.2,44.12 v4(172.08,44.25)
  BOTTOM w0.127: U25.AK20 157.35,89.25 v2(157.65,89.55) ; v4(172.08,44.25) 172.36,44.25 172.87,44.76 172.87,46.05 172.35,46.57 JDIM1.193
M_B_DQ61: length 58.4
  IN1 w0.076: 160.68,83.51 160.25,83.94 160.25,84.84 159.99,85.09 159.1,85.09 158.85,85.34 158.85,87.51 157.73,88.64 157.08,88.64 v2(156.72,88.27)
  IN1 w0.14: v4(172.05,40.86) 171.59,41.31 171.59,44.4 172.11,44.92 172.43,44.92 172.67,45.16 172.67,56.01 171.85,56.82 171.85,62.65 171.3,63.21 171.3,69.27 162.04,78.52 162.04,79.72 161.31,80.44 161.31,82.88 160.68,83.51
  BOTTOM w0.076: U25.AM20 157.05,87.95 v2(156.72,88.27)
  BOTTOM w0.127: JDIM1.192 172.05,40.85 v4(172.05,40.86)
M_B_DQ62: length 55.1
  IN1 w0.076: 159.77,82.63 159.44,82.97 159.27,82.97 157.66,84.58 v2(157.66,85.6)
  IN1 w0.14: 159.77,82.63 159.87,82.53 159.87,79.8 160.59,79.08 160.59,77.41 163.8,74.2 163.8,73.79 169.3,68.29 169.3,57.02 169.42,56.9 169.74,56.9 169.86,56.78 169.86,56.61 169.74,56.48 169.42,56.48 169.3,56.36 169.3,56.19 169.42,56.06 169.74,56.06 169.86,55.94 169.86,55.77 169.74,55.64 169.42,55.64 169.3,55.52 169.3,55.35 169.42,55.23 169.74,55.23 169.86,55.1 169.86,54.93 169.74,54.81 169.42,54.81 169.3,54.68 169.3,54.51 169.42,54.39 169.74,54.39 169.86,54.26 169.86,54.09 169.74,53.97 169.42,53.97 169.3,53.85 169.3,53.67 169.42,53.55 169.74,53.55 169.86,53.43 169.86,53.25 169.74,53.13 169.42,53.13 169.3,53.01 169.3,52.83 169.42,52.71 169.74,52.71 169.86,52.59 169.86,52.41 169.74,52.29 169.42,52.29 169.3,52.17 169.3,52 169.42,51.87 169.74,51.87 169.86,51.75 169.86,48.7 169.98,48.58 170.3,48.58 170.43,48.46 170.43,48.28 170.3,48.16 169.98,48.16 169.86,48.04 169.86,47.86 169.98,47.74 170.3,47.74 170.43,47.62 170.43,47.45 170.3,47.32 169.98,47.32 169.86,47.2 169.86,46.36 170.03,46.19 v4(170.29,46.19)
  BOTTOM w0.076: v2(157.66,85.6) 158.05,86 U25.AR18
  BOTTOM w0.127: JDIM1.183 169.35,46.12 169.7,45.77 169.86,45.77 v4(170.29,46.19)
M_B_DQ63: length 56.1
  IN1 w0.076: v2(157.67,86.32) 158.06,85.93 158.06,84.46 159.39,83.13 159.6,83.13 160.04,82.69
  IN1 w0.14: 160.04,82.69 160.1,82.63 160.1,79.9 160.83,79.17 160.83,77.51 164.18,74.16 164.18,73.89 169.64,68.43 169.64,62.4 169.77,62.27 169.89,62.27 170.02,62.15 170.02,61.98 169.89,61.85 169.77,61.85 169.64,61.73 169.64,61.56 169.77,61.43 170.08,61.43 170.2,61.31 170.2,61.14 170.08,61.02 169.77,61.02 169.64,60.89 169.64,60.72 169.77,60.6 170.08,60.6 170.2,60.47 170.2,60.3 170.08,60.18 169.77,60.18 169.64,60.05 169.64,59.88 169.77,59.76 170.08,59.76 170.2,59.64 170.2,59.46 170.08,59.34 169.77,59.34 169.64,59.22 169.64,59.04 169.77,58.92 170.08,58.92 170.2,58.8 170.2,58.62 170.08,58.5 169.77,58.5 169.64,58.38 169.64,58.2 169.77,58.08 170.08,58.08 170.2,57.96 170.2,57.79 170.08,57.66 169.77,57.66 169.64,57.54 169.64,57.37 169.77,57.24 170.08,57.24 170.2,57.12 170.2,51.49 170.77,50.93 170.77,45.9 170.31,45.45 v4(170.31,44.92)
  BOTTOM w0.076: U25.AP18 157.99,86.65 v2(157.67,86.32)
  BOTTOM w0.127: JDIM1.181 168.75,46.08 169.91,44.92 v4(170.31,44.92)
M_B_DQSN0: length 59
  IN1 w0.076: v2(132.05,87.53) 131.88,87.36 131.62,87.36 130.69,86.42 130.69,85.24 129.96,84.52 129.96,83.59 129.35,82.98 129.35,81.79 129.19,81.63 129.11,81.63
  IN1 w0.14: v4(120.79,44.03) 120.64,44.18 120.3,44.18 120,44.48 120,46.97 118.59,48.38 118.59,61.07 118.89,61.36 119.56,61.36 119.71,61.52 119.71,61.99 119.56,62.14 118.89,62.14 118.59,62.44 118.59,63.15 118.89,63.45 119.56,63.45 119.71,63.6 119.71,64.07 119.56,64.22 118.94,64.22 118.63,64.53 118.63,65.22 118.94,65.53 119.56,65.53 119.71,65.68 119.71,72.23 129.11,81.63
  BOTTOM w0.076: U25.AM58 132.47,87.95 v2(132.05,87.53)
  BOTTOM w0.127: JDIM1.27 120.15,46.6 120.22,46.53 120.22,46.42 120.04,46.25 120.04,44.76 120.32,44.48 120.67,44.48 120.79,44.36 v4(120.79,44.03)
M_B_DQSN1: length 55.4
  IN1 w0.076: 130.99,78.69 131.06,78.69 131.13,78.76 131.13,82.24 134.29,85.39 134.29,87.18 134.16,87.3 134.16,87.85 134.38,88.07 134.62,88.07 v2(134.83,88.29)
  IN1 w0.14: 130.99,78.69 130.34,78.04 130.34,76.99 124.14,70.79 124.14,61.78 123.6,61.24 123.6,48.87 125.59,46.88 125.59,44.79 125.98,44.4 126.48,44.4 v4(126.63,44.25)
  BOTTOM w0.076: v2(134.83,88.29) 134.49,87.95 U25.AM55
  BOTTOM w0.127: v4(126.63,44.25) 126.63,44.59 126.47,44.75 126.04,44.75 125.53,45.26 125.53,45.98 125.72,46.17 125.72,46.41 125.55,46.58 JDIM1.45
M_B_DQSN2: length 80.1
  IN1 w0.076: 130.23,89.91 130.23,89.99 131.23,90.98 132.48,90.98 133.02,90.45 137.69,90.45 138.02,90.78 140.28,90.78 141.92,89.14 141.92,88.88 142.43,88.37 v2(142.43,88.29)
  IN1 w0.14: v4(114.59,41.57) 114.59,42.09 114.78,42.28 115.13,42.28 115.43,42.57 115.43,44.02 115.11,44.34 114.74,44.34 114.59,44.49 114.59,44.83 114.74,44.98 115.07,44.98 115.38,45.29 115.38,45.86 115.07,46.17 114.49,46.17 114.32,46.33 114.32,69.88 114.97,70.54 114.97,72.72 117.29,75.04 117.29,84.12 120.69,87.52 124.65,87.52 124.91,87.26 127.06,87.26 127.46,87.67 127.98,87.67 130.23,89.91
  BOTTOM w0.076: U25.AL43 142.12,88.6 v2(142.43,88.29)
  BOTTOM w0.127: v4(114.59,41.57) 114.59,41.9 114.73,42.04 114.99,42.04 115.24,41.79 115.24,40.77 115.05,40.58 JDIM1.10
M_B_DQSN3: length 58.8
  IN1 w0.076: 134.72,76.99 134.67,77.04 134.67,77.16 135.03,77.52 135.03,82.54 137.64,85.15 138.02,85.15 138.26,85.4 138.26,88.13 138.43,88.29 v2(138.62,88.29)
  IN1 w0.14: v4(131.19,43.06) 131.39,42.86 131.39,42.6 131.21,42.42 130.79,42.42 130.67,42.54 130.67,43.84 131.65,44.82 131.65,46.7 128.93,49.42 128.93,51.99 128.32,52.6 128.32,64.39 128.93,65 128.93,69.69 129.81,70.57 130.35,70.57 131.44,71.66 131.44,72.11 131.97,72.64 131.97,73.09 134.72,75.83 134.72,76.99
  BOTTOM w0.076: v2(138.62,88.29) 138.93,88.6 U25.AL48
  BOTTOM w0.127: JDIM1.62 130.65,40.75 130.36,41.05 130.36,42.27 130.63,42.54 131.04,42.54 131.19,42.7 v4(131.19,43.06)
M_B_DQSN4: length 55.5
  IN1 w0.076: 150.62,77.04 150.57,77.09 150.57,77.32 149.16,78.73 149.16,82.82 149.44,83.1 149.44,84.13 150.3,84.99 150.3,85.67 150.72,86.09 150.72,87.55 150.89,87.72 151.01,87.72 151.11,87.62 v2(151.11,86.97)
  IN1 w0.14: 150.62,77.04 150.62,75.26 153.5,72.38 153.5,69 157.48,65.02 157.48,57.91 158.21,57.18 158.21,54.41 155.97,52.18 155.97,46.99 154.8,45.81 154.8,44.87 155.01,44.66 155.2,44.66 155.32,44.78 v4(155.32,45.49)
  BOTTOM w0.076: U25.AN28 151.44,87.3 v2(151.11,86.97)
  BOTTOM w0.127: v4(155.32,45.49) 155.32,45.09 155.45,44.96 155.65,44.96 155.77,45.08 155.77,45.73 155.55,45.95 155.4,45.95 155.14,46.21 155.14,46.41 154.95,46.6 JDIM1.135
M_B_DQSN5: length 56.3
  IN1 w0.076: v2(152.87,87.59) 152.87,87.73 153.02,87.87 153.16,87.87 153.27,87.77 153.27,83.39 154.01,82.65 154.01,77.36 153.77,77.12 153.77,75.89 156.27,73.39 156.47,73.39 156.73,73.14 156.73,73.07
  IN1 w0.14: v4(160.16,41.64) 160.16,42.1 159.88,42.38 159.73,42.38 159.38,42.73 159.38,44.06 160.09,44.78 160.09,46.47 161.07,47.45 161.07,52.16 161.86,52.95 161.86,65.76 157.12,70.5 157.12,72.67 156.73,73.07
  BOTTOM w0.076: v2(152.87,87.59) 153.11,87.59 U25.AN25
  BOTTOM w0.127: v4(160.16,41.64) 160.16,41.95 160.3,42.09 160.47,42.09 160.61,41.95 160.61,40.85 160.05,40.29 JDIM1.152
M_B_DQSN6: length 54.4
  IN1 w0.076: v2(155.76,86.97) 155.71,87.02 155.45,87.02 155.38,86.95 155.38,86.67 155.26,86.55 155.26,86.26 155.61,85.91 155.61,84 156.8,82.82 156.8,82.34 157.33,81.81 157.33,77.07 161.28,73.12 161.28,72.85 161.33,72.8
  IN1 w0.14: 161.33,72.8 161.33,72.17 166.02,67.48 166.02,61.58 166.55,61.05 166.55,51.35 166.13,50.94 166.13,49.04 166.55,48.62 166.55,44.53 166.13,44.12 165.91,44.12 165.73,43.95 v4(165.73,43.69)
  BOTTOM w0.076: v2(155.76,86.97) 156.09,87.3 U25.AN21
  BOTTOM w0.127: v4(165.73,43.69) 165.73,44.1 165.61,44.22 165.36,44.22 165.02,44.56 165.02,45.9 165.3,46.18 165.3,46.37 165.15,46.52 JDIM1.169
M_B_DQSN7: length 57.3
  IN1 w0.076: 160.46,82.12 160.51,82.17 160.51,82.62 159.82,83.31 159.46,83.31 158.33,84.43 158.33,86.29 158.12,86.5 158.12,87.09 158.02,87.19 157.88,87.19 v2(157.67,86.97)
  IN1 w0.14: v4(170.27,43.5) 170.27,42.99 170.38,42.88 170.54,42.88 170.8,43.14 170.8,44.72 171.29,45.21 171.29,51.15 170.72,51.71 170.72,62.18 170.16,62.74 170.16,68.75 161.2,77.71 161.2,79.29 160.46,80.03 160.46,82.12
  BOTTOM w0.076: v2(157.67,86.97) 157.99,87.3 U25.AN18
  BOTTOM w0.127: JDIM1.186 170.25,40.5 170.44,40.68 170.44,40.75 170.35,40.84 170.02,40.84 169.56,41.29 169.56,42.62 169.82,42.88 170.06,42.88 170.27,43.09 v4(170.27,43.5)
M_B_DQSP0: length 58.8
  IN1 w0.076: v2(132.03,86.89) 132.03,87.01 131.85,87.19 131.69,87.19 130.85,86.36 130.85,85.17 130.13,84.45 130.13,83.52 129.51,82.91 129.51,81.72 129.3,81.51 129.3,81.44
  IN1 w0.14: v4(120.79,45.3) 120.79,44.62 120.62,44.45 120.41,44.45 120.27,44.59 120.27,47.08 118.86,48.49 118.86,60.96 119,61.1 119.67,61.1 119.98,61.41 119.98,62.1 119.67,62.41 119,62.41 118.86,62.55 118.86,63.04 119,63.18 119.67,63.18 119.98,63.49 119.98,64.18 119.67,64.49 119.05,64.49 118.89,64.64 118.89,65.11 119.05,65.26 119.67,65.26 119.98,65.57 119.98,72.12 129.3,81.44
  BOTTOM w0.076: v2(132.03,86.89) 132.43,87.3 U25.AN58
  BOTTOM w0.127: JDIM1.29 120.75,46.63 120.27,46.15 120.27,44.86 120.42,44.71 120.64,44.71 120.79,44.86 v4(120.79,45.3)
M_B_DQSP1: length 55.1
  IN1 w0.076: v2(134.83,87.65) 134.83,87.81 134.73,87.91 134.45,87.91 134.33,87.78 134.33,87.37 134.45,87.24 134.45,85.33 131.3,82.17 131.3,78.69 131.17,78.57 131.17,78.57 131.17,78.5
  IN1 w0.14: v4(126.63,45.52) 126.63,44.84 126.46,44.66 126.09,44.66 125.86,44.9 125.86,46.99 123.87,48.98 123.87,61.13 124.41,61.67 124.41,70.68 130.61,76.88 130.61,77.93 131.17,78.5
  BOTTOM w0.076: v2(134.83,87.65) 134.48,87.3 U25.AN55
  BOTTOM w0.127: JDIM1.47 126.15,46.58 125.98,46.41 125.98,46.06 125.76,45.85 125.76,45.35 126.14,44.98 126.46,44.98 126.63,45.15 v4(126.63,45.52)
M_B_DQSP2: length 80.1
  IN1 w0.076: 130.04,90.1 130.11,90.1 131.16,91.15 132.55,91.15 133.09,90.61 137.62,90.61 137.95,90.94 140.35,90.94 142.08,89.21 142.08,88.94 142.16,88.87 142.38,88.87 v2(142.43,88.92)
  IN1 w0.14: 130.04,90.1 127.87,87.94 127.35,87.94 126.95,87.53 125.02,87.53 124.76,87.78 120.58,87.78 117.02,84.23 117.02,75.15 114.7,72.83 114.7,70.65 114.05,69.99 114.05,46.22 114.37,45.9 114.96,45.9 115.11,45.75 115.11,45.4 114.96,45.25 114.63,45.25 114.32,44.94 114.32,44.38 114.63,44.07 115,44.07 115.16,43.91 115.16,42.68 115.02,42.54 114.77,42.54 114.59,42.72 v4(114.59,42.84)
  BOTTOM w0.076: v2(142.43,88.92) 142.75,88.6 U25.AL42
  BOTTOM w0.127: JDIM1.12 115.65,40.58 115.46,40.77 115.46,41.89 115.09,42.27 114.73,42.27 114.59,42.41 v4(114.59,42.84)
M_B_DQSP3: length 58.4
  IN1 w0.076: v2(137.69,88.27) 137.76,88.27 138.1,87.94 138.1,85.47 137.95,85.32 137.57,85.32 134.86,82.61 134.86,77.59 134.5,77.23 134.5,77.04 134.45,76.99
  IN1 w0.14: v4(131.19,41.79) 131.19,41.95 130.99,42.15 130.68,42.15 130.4,42.43 130.4,43.95 131.38,44.93 131.38,46.59 128.66,49.31 128.66,51.88 128.05,52.49 128.05,64.5 128.66,65.11 128.66,69.8 129.7,70.84 130.24,70.84 131.18,71.77 131.18,72.22 131.71,72.75 131.71,73.2 134.45,75.94 134.45,76.99
  BOTTOM w0.076: U25.AL49 138.01,88.6 v2(137.69,88.27)
  BOTTOM w0.127: v4(131.19,41.79) 131.19,42.1 130.97,42.32 130.73,42.32 130.59,42.17 130.59,41.14 131.25,40.48 JDIM1.64
M_B_DQSP4: length 55.4
  IN1 w0.076: v2(151.02,88.22) 151.02,87.96 150.94,87.88 150.82,87.88 150.56,87.62 150.56,86.16 150.14,85.74 150.14,85.06 149.27,84.2 149.27,83.16 148.99,82.89 148.99,78.66 150.4,77.25 150.4,77.09 150.35,77.04
  IN1 w0.14: v4(155.32,44.22) 155.15,44.39 154.9,44.39 154.53,44.76 154.53,45.92 155.71,47.1 155.71,52.29 157.94,54.53 157.94,57.07 157.21,57.8 157.21,64.91 153.24,68.89 153.24,72.27 150.35,75.15 150.35,77.04
  BOTTOM w0.076: U25.AM28 151.3,87.95 v2(151.02,88.22)
  BOTTOM w0.127: JDIM1.137 155.55,46.61 155.36,46.43 155.36,46.3 155.49,46.18 155.65,46.18 156,45.83 156,44.98 155.74,44.73 155.5,44.73 155.32,44.55 v4(155.32,44.22)
M_B_DQSP5: length 56.1
  IN1 w0.076: 156.92,73.25 156.85,73.25 156.54,73.56 156.34,73.56 153.94,75.96 153.94,77.06 154.18,77.29 154.18,82.71 153.43,83.46 153.43,87.83 153.23,88.04 153.08,88.04 v2(152.87,88.24)
  IN1 w0.14: 156.92,73.25 157.39,72.78 157.39,70.61 162.13,65.87 162.13,52.84 161.34,52.05 161.34,47.34 160.36,46.36 160.36,44.67 159.64,43.95 159.64,42.84 159.84,42.65 160.03,42.65 160.16,42.78 v4(160.16,42.91)
  BOTTOM w0.076: v2(152.87,88.24) 153.17,87.95 U25.AM25
  BOTTOM w0.127: v4(160.16,42.91) 160.16,42.46 160.27,42.35 160.53,42.35 160.84,42.05 160.84,40.76 160.65,40.57 JDIM1.154
M_B_DQSP6: length 54.2
  IN1 w0.076: v2(155.75,87.61) 155.75,87.56 155.21,87.02 155.21,86.73 155.09,86.61 155.09,86.19 155.45,85.84 155.45,83.93 156.63,82.75 156.63,82.27 157.16,81.74 157.16,77 157.26,76.9 161.11,73.05 161.11,72.85 161.06,72.8
  IN1 w0.14: 161.06,72.8 161.06,72.06 165.75,67.37 165.75,61.47 166.28,60.94 166.28,51.46 165.86,51.05 165.86,48.93 166.28,48.51 166.28,44.64 166.02,44.39 165.87,44.39 165.76,44.5 v4(165.76,44.96)
  BOTTOM w0.076: U25.AM21 156.09,87.95 v2(155.75,87.61)
  BOTTOM w0.127: JDIM1.171 165.75,46.52 165.53,46.3 165.53,46.08 165.25,45.8 165.25,44.65 165.45,44.45 165.66,44.45 165.76,44.55 v4(165.76,44.96)
M_B_DQSP7: length 57.2
  IN1 w0.076: v2(157.64,87.61) 157.9,87.35 158.09,87.35 158.29,87.16 158.29,86.57 158.49,86.36 158.49,84.5 159.52,83.47 159.89,83.47 160.68,82.69 160.68,82.17 160.73,82.12
  IN1 w0.14: v4(170.27,42.23) 171.07,43.03 171.07,44.61 171.56,45.1 171.56,51.26 170.99,51.82 170.99,62.29 170.43,62.85 170.43,68.86 161.47,77.82 161.47,79.4 160.73,80.14 160.73,82.12
  BOTTOM w0.076: U25.AM18 157.97,87.95 v2(157.64,87.61)
  BOTTOM w0.127: v4(170.27,42.23) 170.27,42.55 170.17,42.65 169.92,42.65 169.79,42.52 169.79,41.38 170.11,41.06 170.44,41.06 170.66,40.85 170.66,40.68 170.85,40.5 JDIM1.188
M_B_ODT0: length 2.8
  TOP w0.127: v2(149.64,40.86) 149.88,40.61 R332.2
  BOTTOM w0.127: JDIM1.116 149.25,40.47 v2(149.64,40.86)
M_B_ODT1: length 2.9
  TOP w0.127: v4(150.74,40.87) 151.15,40.46 R333.2
  BOTTOM w0.127: JDIM1.120 150.45,40.58 v4(150.74,40.87)
M_B_RAS#: length 64.8
  IN1 w0.076: v2(146.77,87.6) 146.39,87.23 146.39,86.86 146.38,86.86 146.38,86.08 146.4,86.06 146.4,84.86 146.38,84.84 146.38,78.33 147,77.71 147,74.87
  IN1 w0.216: v4(148.46,41.05) 148.49,41.02 148.49,39.18 148.26,38.96 147.89,38.96 147.66,39.18 147.66,42.79 148,43.13 148.93,43.13 149.12,43.32 149.12,43.59 148.93,43.78 148.6,43.78 148.37,44.01 148.37,44.28 148.6,44.51 148.6,52.91 151.76,56.08 151.76,58.51 151.57,58.7 149.83,58.7 149.64,58.89 149.64,59.16 149.83,59.35 151.57,59.35 151.76,59.54 151.76,59.81 151.57,60 150.25,60 149.86,60.39 149.86,64.03 149.32,64.57 149.32,65.1 146.89,67.52 146.89,74.76 147,74.87 147,74.87
  BOTTOM w0.076: U25.AM35 147.11,87.95 v2(146.77,87.6)
  BOTTOM w0.191: v4(148.46,41.05) 148.16,41.35 147.88,41.35 147.45,40.92 JDIM1.110
