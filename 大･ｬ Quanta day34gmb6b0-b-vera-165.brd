# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CK_XDP_N_R: length 9.8
  TOP w0.127: v2(147.62,109.19) 147.46,109.36 147.02,109.36 146.76,109.62 146.76,110.88 147.15,111.26 RP1.4
  BOTTOM w0.076: U25.B35 147.06,104.92 147.38,105.25 147.38,105.91 146.99,106.3 146.99,106.56 147.1,106.68 147.1,106.97 147.17,107.03
  BOTTOM w0.127: v2(147.62,109.19) 147.42,109.4 147.01,109.4 146.78,109.17 146.78,108.62 147.19,108.22 147.19,107.06 147.17,107.03
CK_XDP_P: length 108.7
  TOP w0.127: RP1.1 147.8,113.82 147.6,114.02 147.6,114.48 148.99,115.88 148.99,116.66 147.9,117.75 147.42,117.75 147.14,118.03 v1(147.14,118.35) 146.42,118.35 145.52,119.25 140.76,119.25 139.85,118.34 133.4,118.34 132.72,117.67 129.91,117.67 128.88,116.64 118.88,116.64 118.24,116 109.81,116 109.3,116.51 103.91,116.51 99.59,112.19 99.59,109.81 80.41,90.64 80.41,80.44 77.95,77.97 76.73,77.97 75.27,76.51 75.27,74.67 76.06,73.88 CN8.11
CK_XDP_P_R: length 9.6
  TOP w0.127: v2(147.6,109.98) 147.6,109.8 147.41,109.61 147.13,109.61 147.01,109.73 147.01,110.77 147.4,111.16 147.4,111.49 147.51,111.59 147.69,111.59 147.8,111.7 RP1.2
  BOTTOM w0.076: U25.A35 147.17,105.51 147.22,105.57 147.22,105.84 146.82,106.23 146.82,106.63 146.94,106.75 146.94,107.11
  BOTTOM w0.127: 146.94,107.11 146.94,108.11 146.53,108.52 146.53,109.27 146.91,109.65 147.39,109.65 147.6,109.86 v2(147.6,109.98)
CLK_24M_DEBUG: length 119.9
  TOP w0.127: R254.2 EC29.2 163.73,74.98 164.23,75.49 165.89,75.49 166.27,75.87 166.27,76.4 167.16,77.29 168.45,77.29 168.76,77.6 168.76,78.03 169.19,78.46 169.19,79.55 169.57,79.93 170.53,79.93 172.39,78.08 172.85,78.08 173.2,77.72 175.97,77.72 176.31,78.07 178.09,78.07 179.07,79.05 179.07,81.94 179.61,82.48 181.78,82.48 183.61,84.31 183.61,89.19 185.75,91.32 186.88,91.32 189.93,94.37 189.93,95.39 191.01,96.46 191.01,106.41 190.14,107.27 190.14,109.78 189.38,110.54 v1(189.38,111.18) 189.38,112.94 190.41,113.97 v2(190.68,113.97) ; v2(182.52,158.17) 182.52,158.68 R91.2 183.66,160.82 184.6,161.77 CN22.19
  IN1 w0.14: v2(182.52,158.17) 183.01,157.68 183.01,155.32 184.82,153.51 184.82,152.95 189.41,148.36 189.41,133.94 192.87,130.47 192.87,115.15 191.69,113.97 v2(190.68,113.97)
CLK_24M_KBC: length 241.2
  TOP w0.127: R242.2 EC26.2 160.77,76.17 160.77,63.68 170.15,54.3 170.15,52.68 172.72,50.11 173.71,50.11 175.41,48.41 175.41,47.47 176.16,46.72 176.16,43.04 176.43,42.77 176.43,36.12 177.09,35.46 177.09,31.59 176.16,30.66 176.16,27.85 175.16,26.85 168.67,26.85 165.26,23.43 164.81,22.99 160.04,22.99 160.04,22.99 159.14,22.99 159.14,22.99 154.81,22.99 152.96,21.14 152.96,20.4 149.99,17.42 131.2,17.42 130.61,16.83 126.9,16.83 123.33,13.26 111.66,13.26 111.07,13.84 104.79,13.84 102.97,15.66 100.37,15.66 97.31,18.72 95.17,18.72 v1(94.26,19.63) 93.67,20.22 91.31,20.22 89.94,21.59 89.94,23.91 86.62,27.23 84.33,27.23 v2(84.2,27.36) ; v2(42.2,71.8) 42.1,71.7 39.79,71.7 39.23,72.26 38.68,72.26 37.61,73.33 U11.13 35.94,73.33 35.3,72.69 R272.1
  IN1 w0.14: v2(84.2,27.36) 84.2,27.74 83.59,28.35 83.59,29.97 76.17,37.4 76.17,43.54 69.62,50.09 69.62,52.91 59.07,63.46 57.04,63.46 56.72,63.78 56.72,68.17 55.37,69.52 54.41,69.52 52.4,71.53 50.72,71.53 50.45,71.8 v2(42.2,71.8)
CLK_PCI_EC_R: length 10
  TOP w0.127: R242.1 161.09,79.46 161.09,84.37 160.02,85.44 160.02,86.27 159.25,87.05 159.25,87.05 159.26,87.04 v3(159.26,87.05)
  BOTTOM w0.127: U25.AN15 159.71,87.05 159.26,87.05 159.26,87.04 v3(159.26,87.05)
CLK_PCI_LPC_R: length 15.1
  TOP w0.127: v2(159.26,86.41) 158.8,86.87 158.8,87.2 159.08,87.48 159.56,87.48 159.82,87.22 159.82,86.8 160.25,86.37 160.25,85.53 161.34,84.44 161.34,79.03 R243.1 162.03,78.33 162.03,77.32 v1(162.4,76.95) 162.57,76.78 R254.1
  BOTTOM w0.127: v2(159.26,86.41) 159.31,86.46 U25.AP15
CLK_PCI_TPM: length 161.4
  TOP w0.127: R243.2 EC27.2 161.03,76.48 161.03,63.78 170.41,54.4 170.41,52.79 172.82,50.37 173.81,50.37 175.66,48.52 175.66,47.57 176.41,46.82 176.41,43.14 176.68,42.88 176.68,36.22 177.34,35.56 177.34,31.48 176.42,30.56 176.42,27.75 175.26,26.59 168.78,26.59 165.51,23.33 164.92,22.73 160.15,22.73 160.15,22.73 159.04,22.73 159.04,22.73 154.91,22.73 153.21,21.03 153.21,20.19 150.19,17.17 131.31,17.17 130.71,16.58 127,16.58 123.43,13.01 111.53,13.01 110.95,13.59 104.68,13.59 102.87,15.41 100.26,15.41 97.2,18.47 93.09,18.47 v1(92.81,18.75) 92,19.56 91.08,19.56 89.63,21.01 86.5,21.01 R391.2 85.87,20.37 84.79,20.37 84.61,20.55 U18.21
CLK_PCIE_CRN: length 180.3
  TOP w0.127: v2(143.91,117.26) 143.58,117.58 143.58,117.98 143.08,118.49 141.35,118.49 139.72,116.87 130.19,116.87 129.2,115.88 119.19,115.88 118.43,115.11 109.6,115.11 108.96,115.75 104.8,115.75 100.35,111.3 100.35,109.49 81.43,90.56 81.43,79.07 85.39,75.11 86.98,75.11 89.06,73.03 89.06,71.67 89.9,70.83 89.9,58.56 89.05,57.71 89.05,53.21 88.9,53.06 88.9,37.5 79.75,28.35 75.16,28.35 70.15,23.34 70.15,21.16 68.22,19.23 66.29,19.23 65.87,18.81 U19.6
  BOTTOM w0.127: U25.A39 144.5,105.46 144.4,105.46 143.99,105.87 143.99,109.91 143.53,110.36 143.53,116.99 143.8,117.26 v2(143.91,117.26)
CLK_PCIE_CRP: length 180.4
  TOP w0.127: v2(143.08,117.22) 143.33,117.48 143.33,117.88 142.97,118.24 141.45,118.24 139.82,116.61 130.29,116.61 129.3,115.62 119.3,115.62 118.54,114.86 109.49,114.86 108.86,115.49 104.9,115.49 100.61,111.2 100.61,109.38 81.68,90.46 81.68,79.17 85.49,75.36 87.09,75.36 89.32,73.13 89.32,71.77 90.16,70.93 90.16,58.45 89.3,57.6 89.3,53.1 89.15,52.95 89.15,37.39 79.85,28.09 75.27,28.09 70.41,23.23 70.41,21.05 68.33,18.97 66.39,18.97 65.98,18.56 65.25,18.56 65.11,18.41 U19.5
  BOTTOM w0.127: U25.B39 144.18,105.24 144.18,105.32 143.74,105.76 143.74,109.8 143.28,110.26 143.28,117.02 v2(143.08,117.22)
CLK_PCIE_LANN: length 184.3
  TOP w0.127: U8.16 21.48,119.82 21.56,119.89 21.56,120.15 21.43,120.28 21.43,121.8 30.38,130.75 30.38,140.2 48.72,158.55 52.44,158.55 53.92,160.02 54.22,160.02 54.78,160.59 55.3,161.11 75.65,161.11 75.9,160.86 82.58,160.86 86.65,156.78 117.78,125.65 119.12,125.65 122.91,121.87 126.64,121.87 129.53,124.76 129.53,125.1 129.43,125.2 v2(129.28,125.2)
  BOTTOM w0.127: v2(129.28,125.2) 129.43,125.2 129.51,125.12 129.51,124.82 129.51,124.82 129.51,124.41 130.02,123.9 137.23,123.9 137.87,123.27 140,123.27 142.86,120.41 142.86,119.95 144.5,118.31 144.5,113.65 145.03,113.12 145.03,111.72 v1(144.51,111.2) 144.96,111.2 145.03,111.13 145.03,104.62 U25.B38
CLK_PCIE_LANP: length 184.3
  TOP w0.127: v2(130.04,125.2) 129.79,124.95 129.79,124.65 126.75,121.61 122.81,121.61 119.02,125.4 117.68,125.4 86.47,156.6 82.47,160.6 75.79,160.6 75.54,160.86 55.41,160.86 55.04,160.49 54.32,159.77 54.03,159.77 52.55,158.29 48.83,158.29 30.63,140.1 30.63,130.64 21.68,121.69 21.68,120.38 21.81,120.25 21.81,119.89 21.88,119.82 U8.15
  BOTTOM w0.076: U25.C37 145.68,104.43 145.31,104.8
  BOTTOM w0.127: v2(130.04,125.2) 129.77,124.93 129.77,124.51 130.12,124.16 137.34,124.16 137.97,123.52 140.1,123.52 143.11,120.51 143.11,120.05 144.75,118.42 144.75,113.76 145.29,113.23 145.29,111.7 v1(145.78,111.2) 145.29,110.71 145.29,104.83 145.31,104.8
CLK_PCIE_WLANN: length 119.4
  IN1 w0.14: CN22.11 178.2,162.02 178.44,161.78 178.44,161.51 178.93,161.02 183.28,161.02 185.54,158.76 185.54,154.29 190.18,149.65 190.18,134.26 193.72,130.72 193.72,114.68 191.26,112.22 180.9,112.22 177.36,115.76 171.55,115.76 167.98,112.19 162.84,112.19 161.57,110.92 144.81,110.92 142.96,109.07 142.44,109.07 v2(142.33,109.19)
  BOTTOM w0.076: U25.C41 143.17,104.45 142.77,104.85
  BOTTOM w0.127: v2(142.33,109.19) 142.5,109.02 142.8,109.02 143.13,108.69 143.13,106.99 142.77,106.63 142.77,104.85
CLK_PCIE_WLANP: length 119.3
  IN1 w0.14: CN22.13 179,162.02 178.76,161.78 178.76,161.64 179.06,161.34 183.41,161.34 185.86,158.9 185.86,154.42 190.5,149.78 190.5,134.39 194.04,130.85 194.04,114.55 191.39,111.9 180.77,111.9 177.23,115.44 171.68,115.44 168.11,111.87 162.97,111.87 161.7,110.6 144.94,110.6 143.09,108.76 142.45,108.76 142.35,108.66 v2(142.35,108.48)
  BOTTOM w0.127: v2(142.35,108.48) 142.35,108.65 142.47,108.76 142.7,108.76 142.87,108.59 142.87,107.09 142.52,106.73 142.52,104.63 U25.B42
CLKGEN_RTC_X1: length 211.5
  TOP w0.127: v2(60.04,69.88) 60.04,72.05 v1(63.83,75.84) 64.87,76.88 64.87,77.22 66.19,78.54 66.9,78.54 68.17,79.81 68.6,79.81 68.8,80 U9.9 ; R582.1 173.4,74.25 173.4,73.99 v2(173.25,73.84)
  IN1 w0.14: v2(60.04,69.88) 60.44,69.88 62,68.32 62,63.25 71.65,53.6 71.65,50.95 78.22,44.38 78.22,38.49 85.41,31.31 85.41,30.21 87.53,28.09 90.42,28.09 91.06,28.73 107.52,28.73 110.49,25.76 111.65,25.76 112.24,25.17 168.17,25.17 168.5,25.5 169.17,26.17 173.69,26.17 176.11,28.59 176.11,31.25 177.62,32.76 177.62,42.16 178.41,42.96 178.41,45.98 176.62,47.77 176.62,55.65 178.23,57.25 178.23,61.03 v2(178.14,61.13)
  BOTTOM w0.127: v2(178.14,61.13) 177.43,61.84 177.43,62.57 176.46,63.54 176.46,64.65 175.56,65.54 175.56,67.29 175.16,67.69 175.03,67.69 173,69.72 173,73.58 v2(173.25,73.84)
CLKRUN#: length 284.4
  TOP w0.127: U11.93 50,76.93 47.97,74.9 47.97,72.94 48.54,72.37 v2(48.54,68.81)
  IN1 w0.14: v2(48.54,68.81) 48.55,68.81 48.86,68.81 49.58,68.1 50.98,68.1 53.16,65.91 53.16,64.35 54.07,63.43 54.07,61.61 54.53,61.15 58.04,57.64 58.04,55.43 61.6,51.87 61.6,51.65 61.6,33.52 62.56,32.56 62.56,28.86 65.92,25.5 66.8,25.5 69.48,22.82 69.48,21.55 73.53,17.5 79.04,17.5 80.24,18.69 81.56,18.69 82.33,17.93 85.52,17.93 85.67,17.78 91.57,17.78 91.91,18.12 105.11,18.12 105.11,18.12 108.73,18.12 109.24,18.63 109.62,19.01 133.84,19.01 134.36,19.53 159.09,19.53 159.76,20.21 161.97,20.21 162.63,19.55 165.4,19.55 165.54,19.69 166.45,19.69 166.8,20.03 170.3,20.03 171.3,21.03 175.86,21.03 182.76,27.93 182.76,34.7 184.62,36.56 184.62,42.21 184.26,42.57 184.26,46.26 184.83,46.83 184.83,46.96 185.65,47.78 185.65,51.67 189.03,55.05 189.03,58.24 184.47,62.8 184.47,64.79 182.59,66.67 182.59,72.5 181.63,73.46 181.63,76.04 179.08,78.59 179.08,78.59 178.93,78.75 178.93,84.09 175.64,87.38 175.64,92.99 178.71,96.06 178.99,96.06 v2(179.17,96.22)
  IN2 w0.14: v3(165.46,95.84) 165.75,95.84 166.22,95.37 167.69,95.37 168.44,94.62 170.54,94.62 171.04,95.12 172.17,95.12 172.44,94.86 174.2,94.86 175.54,96.2 179.13,96.2 v2(179.17,96.22)
  BOTTOM w0.089: v3(165.46,95.84) 165.46,95.55 U25.V5
  BOTTOM w0.127: v2(179.17,96.22) 179.22,96.29 R526.2
COMBO-DET: length 16.6
  TOP w0.127: v2(182.7,18.21) 182.73,18.18 182.73,17.47 182.68,17.42 U20.46
  BOTTOM w0.127: v2(182.7,18.21) 183.16,17.75 v1(183.16,17.35) 183.16,14.69 182.48,14.01 182.44,14.01 182.18,13.75 182.18,13.71 179.95,11.48 179.83,11.48 179.76,11.42 178.14,11.42 176.67,9.94 175.34,9.94 R610.2
COMBO-DET_R: length 14.5
  TOP w0.127: v2(185.32,4.42) R435.1 184.16,5.38 C595.1 183.51,4.75 181.76,4.75 181.51,5 R434.2 v2(180.94,4.81)
  BOTTOM w0.127: v2(180.94,4.81) 180.43,5.32 176.47,5.32 174.22,7.58 R610.1
CPIO29: length 3.4
  TOP w0.127: v3(165.45,87.75) 165.45,88.17 164.79,88.82 164.41,88.82 163.98,88.4 TP51.1
  BOTTOM w0.076: v3(165.45,87.75) 165.11,88.09 U25.AM5
CRY1: length 2.3
  TOP w0.127: R281.1 34.74,71.09 35.55,71.09 35.71,70.93 U11.19
CSCOMP: length 41.9
  TOP w0.203: PU3.19 90.57,83.6 ; PC55.1 PC54.1
  TOP w0.254: v2(86.26,83.62) 86.17,83.62 85.37,82.81 85.37,81.33 85.76,80.94 PR90.1 87.01,80.94 v1(87.27,81.2) 87.52,81.2 PR92.1 88.53,82.73 88.42,82.85 PC54.1 ; 90.57,83.6 90.46,83.48 PC55.1
  IN1 w0.254: v2(86.26,83.62) 86.26,85.65 85.88,86.03 85.88,88.75 99.92,102.79 v2(100.61,102.79)
  BOTTOM w0.254: v2(100.61,102.79) 100.86,102.54 105.04,102.54 PR160.1
CSON: length 35.5
  TOP w0.127: PC237.1 89.03,174.76 v2(89.03,173.99) 89.04,173.99 89.16,173.86 v2(89.69,173.86)
  TOP w0.254: PR219.2 90.61,175.33 PC238.2 90.26,174.86 PC237.1
  IN1 w0.14: v2(89.69,173.86) 89.95,174.13 89.95,174.28 90.26,174.59 90.74,174.59 93.07,172.25 104.59,172.25 109.52,177.18 115.74,177.18 v2(115.92,177.37)
  BOTTOM w0.127: PR138.1 114.78,177.62 115.16,177.24 115.8,177.24 v2(115.92,177.37)
CSOP: length 35.3
  TOP w0.127: PR220.2 91.67,175.59 v2(92.56,175.59) ; PC236.1 91.25,173.84 v2(90.32,173.84)
  TOP w0.254: PR220.2 91.62,174.73 PC238.1 91.61,174.28 PC236.1
  IN1 w0.14: v2(90.32,173.84) 90.22,173.94 90.22,174.17 90.37,174.32 90.63,174.32 92.96,171.98 104.7,171.98 109.63,176.92 115.71,176.92 v2(115.9,176.73)
  BOTTOM w0.127: v2(115.9,176.73) 115.7,176.94 115.09,176.94 PR136.1
CSREF: length 5
  TOP w0.127: v1(88.58,87.35) 88.58,87.12 89.1,86.6 89.12,86.6 PR75.1
  TOP w0.203: PU3.17 90.83,84.4
  TOP w0.254: 90.83,84.4 90.45,84.4 90.32,84.53 90.19,84.53 89.69,85.03 PC53.2 89.69,85.49 89.31,85.87 PR75.1
CSSUM: length 5.9
  TOP w0.203: PU3.18 90.83,84
  TOP w0.254: PR85.1 PR80.1 87.76,84.4 87.91,84.26 PC54.2 PC55.2 89.69,84 v2(90.12,84) 90.83,84
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.076: U25.B3 166.78,104.99 U25.A3
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.127: U25.A61 130.53,105.19 130.6,105.12 U25.B61
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.076: U25.AW2 167.25,83 U25.AY2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: U25.AW3 166.65,83.49 U25.AY3
DC_TEST_AY61_AW61: length 5.1
  BOTTOM w0.127: v2(129.03,79.12) 129.03,81.21 130.5,82.69 U25.AY61 130.5,83.46 U25.AW61
DC_TEST_AY62_AW62: length 5.4
  BOTTOM w0.127: U25.AW62 129.94,82.97 U25.AY62 129.85,82.46 127.64,80.25 v2(127.64,79.12)
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.127: U25.B62 129.42,104.79 U25.B63
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.127: U25.C2 167.79,104.26 U25.C1
DDR3_DRAMRST#: length 129.6
  TOP w0.127: v2(120.93,37.64) 120.67,37.64 120.04,37.01 120.04,34.59 C471.2 C472.2 121.56,33.43 121.32,33.18 121.32,28.09 v2(121.18,27.95) ; v2(164.21,24.64) 164.21,24.82 165.61,26.21 165.61,28.11 165.87,28.37 165.87,31.28 166.11,31.53 166.11,33.3 167.89,35.08 167.99,35.08 168.76,35.84 168.76,51.59 158.91,61.43 158.91,73.24 156.51,75.65 156.51,76.02 157,76.51 R266.1 157.45,76.59 158.82,77.96 v1(158.82,82.6) 158.82,83.04 v2(159.67,83.89)
  BOTTOM w0.102: 121.05,24.54 JDIM2.30
  BOTTOM w0.127: JDIM1.30 121.05,37.77 v2(120.93,37.64) ; v2(121.18,27.95) 121.05,27.82 JDIM2.30 ; v2(159.67,83.89) 159.37,84.19 U25.AV15 ; 121.05,24.54 121.05,24.31 121.74,23.62 134.01,23.62 134.23,23.41 151.57,23.41 151.95,23.79 151.96,23.79 152.37,24.2 162.88,24.2 163.32,24.64 v2(164.21,24.64)
DDR_PG_CNTL: length 109.7
  TOP w0.127: Q26.2 141.7,19.86 125.53,19.86 124.64,20.75 124.64,21.69 123.55,22.77 v1(122.9,22.77) 122.68,22.99 122.68,24.46 122.32,24.82 121.94,24.82 121.3,25.45 111.5,25.45 106.07,30.89 106.07,63.66 116.9,74.49 117.38,74.49 v2(120.42,77.52)
  BOTTOM w0.076: U25.AV61 130.54,84.53 129.71,84.53 129.69,84.51 129.15,84.51 128.6,83.96
  BOTTOM w0.127: v2(120.42,77.52) 123.83,77.52 128.6,82.29 128.6,83.96
DDR_THERMDA: length 8.8
  TOP w0.254: v1(109.5,25.83) 109.5,24.44 108.48,23.42 Q23.3 109.12,22.4 109.24,22.53 110.39,22.53 110.52,22.67 C534.1 111.09,22.6 U16.2
DDR_THERMDC: length 10.2
  TOP w0.254: v1(107.47,25.83) 107.47,24.44 107.72,24.18 107.72,21.66 107.87,21.51 109.12,21.51 109.62,22.02 110.39,22.02 110.52,21.89 C534.2 111.09,21.95 U16.3
DDR_VTT_PG_CTRL: length 51.7
  TOP w0.508: R383.2 R382.1 109.25,31.42 109,31.17 109,29.53 111.8,26.72 121.66,26.72 122.38,26.01 123.61,26.01 124.64,24.98 124.64,23.44 127.14,20.94 139.02,20.94 Q24.2 139.6,21.74 140.99,23.14 v1(140.99,23.42) 141.25,23.67 146.84,23.67 Q25.3 148.17,23.48 R373.1
DDR_VTTREF: length 3.8
  TOP w0.127: v1(91.18,37.29) 91.44,37.29 91.84,36.88 92.61,36.88 93.17,37.45 PC107.1 93.63,37.64 93.75,37.76 PR126.1
DEEP_PWRLED#: length 324.3
  TOP w0.127: v2(190.09,23.11) 190.37,22.83 195.56,22.83 195.84,23.11 197.19,23.11 197.83,23.75 CN14.18 ; v2(31.65,170.61) 26.57,170.61 26.03,171.15 Q1.3 26.03,173 26.07,173.03 EC4.1 C60.1 R57.1 26.31,176.33 v1(27.33,175.31) 29.23,173.41 31.65,173.41 31.8,173.56 CN5.2
  IN2 w0.14: v2(56.06,68.02) 56.06,67.89 56.39,67.56 56.39,62.77 57.67,61.48 58.95,61.48 63.9,56.54 63.9,56.54 68.6,51.84 68.6,50.7 77.46,41.84 77.46,40.9 77.46,40.16 84.86,32.76 84.94,32.76 89.52,28.18 89.52,26.33 90.75,25.1 90.75,14.22 89.81,13.28 v2(89.51,13.28)
  BOTTOM w0.127: v2(56.06,68.02) 56.06,68.31 52.49,71.88 52.49,75.73 45.52,82.7 45.52,89.81 40.66,94.67 40.66,97.21 40.17,97.7 40.17,103.94 30.07,114.04 30.07,117.98 30.88,118.8 30.88,149.66 31.08,149.85 31.08,170.04 v2(31.65,170.61) ; v2(89.51,13.28) 89.51,12.9 90.59,11.82 94.21,11.82 95.22,10.81 108.27,10.81 108.52,11.05 117.7,11.05 117.71,11.06 121.58,11.06 123.26,12.75 143.78,12.75 146.49,15.46 162.19,15.46 162.61,15.03 163.02,14.63 165.71,14.63 167.36,12.98 167.38,12.98 168.15,12.21 175.86,12.21 177.57,13.92 177.57,13.93 178.73,13.93 179.62,14.83 179.63,14.83 180.77,15.98 180.77,18.18 185.2,22.62 188.3,22.62 189.01,23.33 189.51,23.33 189.77,23.07 190.05,23.07 v2(190.09,23.11)
DEVSLP0: length 19.3
  IN2 w0.14: v3(168.51,97.88) 168.52,97.88 170.1,99.47 170.1,100.67 171.27,101.84 175.66,101.84 177.09,100.41 177.87,100.41 178.2,100.08 179.85,100.08 181.45,98.48 v2(181.46,98.48)
  BOTTOM w0.076: U25.P2 167.56,97.84 168.47,97.84 v3(168.51,97.88)
  BOTTOM w0.127: v2(181.46,98.48) 181.51,98.48 182.13,99.1 R515.1
DEVSLP1: length 354.9
  TOP w0.127: R602.1 R601.1 92.48,26.32 v2(92.09,26.72) ; R318.1 84.1,47.04 v1(84.22,46.91) 84.63,46.51 85.67,46.51 86.38,45.8 86.38,38.56 v2(81.8,33.97) 78.69,30.86 74.12,30.86 69.28,26.02 64.12,26.02 62.43,27.71 58.72,27.71 54.94,23.93 54.94,15.62 58,12.56 61.41,12.56 62.02,11.95 68.44,11.95 v2(70.58,9.8)
  IN1 w0.14: v2(192.39,50.39) 192.42,50.39 192.88,50.85 192.88,51.95 192.88,52.61 193.69,53.42 193.69,56.2 192.92,56.96 192.92,58.62 191.54,60 191.54,68.3 190.52,69.32 190.52,74.65 188.19,76.98 186.83,78.34 185.63,79.54 185.63,83.59 184.46,84.76 184.46,89.53 190.07,95.14 190.07,98.63 189.43,99.26 189.43,100.65 188.75,101.34 181.97,101.34 v2(181.94,101.37)
  BOTTOM w0.089: U25.L2 167.56,99.34 169.15,99.34 169.47,99.67 169.47,100.26
  BOTTOM w0.127: v2(192.39,50.39) 192.39,49.63 195.83,46.2 199.47,46.2 202.49,43.18 202.49,35.87 201.29,34.67 199.34,34.67 198.5,33.83 198.5,28.14 197.14,26.78 186.47,26.78 183.28,23.59 182.95,23.59 179.5,20.14 179.5,18.68 180.26,17.91 180.26,16.19 179.42,15.34 179.41,15.34 178.51,14.44 177.33,14.44 175.61,12.72 168.79,12.72 167.89,13.61 167.89,14.79 167.88,14.8 167.88,15.07 167.47,15.48 162.89,15.48 162.4,15.96 161.98,15.96 146.28,15.96 144.29,13.97 120.47,13.97 118.42,11.91 108.23,11.91 107.63,11.32 95.59,11.32 94.53,12.38 91.68,12.38 88.31,15.75 85.94,15.75 83.47,13.27 83.43,13.27 79.96,9.8 v2(70.58,9.8) ; v2(81.8,33.97) 82.04,34.21 88.03,34.21 92.09,30.16 v2(92.09,26.72) ; v2(181.94,101.37) 181.94,101.37 180.99,100.42 177,100.42 176.86,100.56 174.46,100.56 173.04,101.98 171.19,101.98 169.47,100.26
DEVSLP2: length 21.9
  TOP w0.127: v2(181.95,104.24) 181.95,104.9 v2(181.97,104.92)
  IN2 w0.14: v2(181.95,104.24) 180.08,102.37 171.05,102.37 169.57,100.89 169.57,99.69 168.55,98.67 v2(165.58,98.67)
  BOTTOM w0.127: v2(181.95,104.24) 182.52,103.66 R499.1 ; U25.N5 165.58,98.53 v2(165.58,98.67)
DGPU_CL_HDMIP: length 17.6
  TOP w0.381: R253.2 v2(18.39,76.51) ; R222.2 v2(18.44,83.62) ; R214.2 v2(18.44,84.89) ; R232.2 v2(18.36,81.08) ; R230.2 v2(18.39,82.35) ; R241.2 v2(18.39,78.79) ; R233.2 v2(18.36,80.06) ; R246.2 v2(18.39,77.78)
  IN1 w0.508: v2(18.44,84.89) v2(18.44,83.62) 18.39,83.57 v2(18.39,82.35) 18.36,82.32 v2(18.36,81.08) v2(18.36,80.06) 18.39,80.04 v2(18.39,78.79) v2(18.39,77.78) v2(18.39,76.51)
  BOTTOM w0.508: Q40.3 15.64,74.47 v1(17.42,76.25) 17.68,76.51 v2(18.39,76.51)
DGPU_HOLD_RST#: length 24.8
  IN2 w0.14: v2(165.49,97.76) 165.07,98.19 163.42,98.19 163.18,98.44 163.18,98.84 163.48,99.14 165.79,99.14 165.99,98.94 167.17,98.94 167.38,99.15 167.38,99.39 170.64,102.64 177.49,102.64 178.34,103.48 v2(178.34,105.46)
  BOTTOM w0.089: v2(165.49,97.76) 165.28,97.55 U25.R5
  BOTTOM w0.127: R492.1 178.9,106.54 178.9,105.52 R493.1 v2(178.34,105.46)
DGPU_PROCHOT#: length 3.5
  TOP w0.127: U11.77 53.94,70.53 55.19,71.78 R8554.2
DGPU_PROCHOT_EC#: length 3.6
  TOP w0.127: U11.71 54.12,68.13 TP11.1 54.89,67.36 R285.2
DGPU_PWR_EN: length 13.7
  BOTTOM w0.076: U25.L3 166.87,98.75 168.03,98.75 168.15,98.87 169.18,98.87 169.9,99.59
  BOTTOM w0.127: R520.1 176.93,98.87 176.58,99.21 176.58,99.49 v2(176.33,99.75) 176.03,100.04 175.38,100.04 174.98,99.64 174.63,99.64 172.8,101.47 171.4,101.47 170.25,100.32 170.24,100.32 169.9,99.97 169.9,99.59
DIGITAL_CLK: length 155.5
  TOP w0.127: C8744.1 L58.2 185.54,149.72 v1(186.66,148.59) 187.04,148.21 v2(187.27,148.21) ; R395.1 178.98,18.56 C555.1 178.54,17.43 178.81,17.43 v2(179.25,16.99)
  IN1 w0.14: v2(179.25,16.99) 179.64,17.39 179.64,19.01 181.04,20.42 181.34,20.42 183.65,22.73 183.65,23.2 183.78,23.33 183.78,24.11 187.13,27.46 187.13,29.93 190.89,33.69 190.89,34.54 190.56,34.86 190.56,42.02 193.66,45.12 193.66,49.53 194.2,50.07 194.2,52.06 195.45,53.32 195.45,56.98 195.09,57.34 194.85,57.34 194.15,58.04 194.15,59.04 192.59,60.59 192.59,68.82 191.62,69.8 191.62,71.68 192.59,72.66 192.59,76.47 192.81,76.68 v2(192.81,77.14)
  IN2 w0.14: v2(192.81,77.14) 192.19,77.76 190.94,77.76 190.03,78.68 190.03,84.72 190.87,85.56 190.87,88.07 193.2,90.41 193.2,91.53 192.24,92.49 192.24,98.48 191.36,99.37 191.36,101.57 190.42,102.51 190.42,108.05 191.67,109.3 191.67,113.74 190.68,114.73 190.68,142.77 189.61,143.84 189.61,147.55 188.95,148.21 v2(187.27,148.21)
DIGITAL_CLK_L: length 2.8
  TOP w0.127: CN31.2 187.42,150.47 v1(187.37,150.42) 187.33,150.47 L58.1
DIGITAL_D1: length 160.1
  TOP w0.127: CN31.3 v2(187.27,151.72) C8743.1 ; R405.1 C569.1 177.2,14.77 176.83,15.14 v2(176.48,15.14)
  IN1 w0.14: v2(193.47,77.14) 193.47,76.78 192.99,76.3 192.99,64.06 193.65,63.4 193.65,60.1 194,59.74 194.54,59.2 194.54,58.21 195.02,57.73 195.25,57.73 195.84,57.14 195.84,53.15 194.59,51.9 194.59,49.91 194.05,49.37 194.05,44.96 190.96,41.86 190.96,35.78 191.79,34.95 191.79,34.03 187.52,29.76 187.52,27.3 184.17,23.95 184.17,22 180.71,18.53 180.71,18.53 180.36,18.18 180.36,17.29 179.3,16.23 177.57,16.23 176.48,15.14 v2(176.48,15.14)
  IN2 w0.14: v2(187.27,151.72) 190,148.98 190,144.21 191.87,142.34 191.87,114.99 192.21,114.66 192.21,107.93 190.81,106.53 190.81,102.67 191.75,101.73 191.75,99.54 192.64,98.65 192.64,92.65 193.6,91.69 193.6,90.25 191.26,87.91 191.26,85.4 190.42,84.56 190.42,78.84 191.11,78.16 192.45,78.16 v2(193.47,77.14)
DIMM0_SA0: length 2.5
  TOP w0.127: R348.1 173.14,36.37 v2(173.68,35.84)
  BOTTOM w0.127: v2(173.68,35.84) 173.55,35.71 JDIM2.197
DIMM0_SA1: length 4.3
  TOP w0.127: R340.1 173.26,37.39 v2(173.66,36.99)
  BOTTOM w0.127: v2(173.66,36.99) 174.14,36.99 174.72,36.41 174.72,35.74 174.75,35.71 JDIM2.201
DIMM1_SA0: length 2.9
  TOP w0.127: R323.1 173.51,46.56 v2(173.89,46.19)
  BOTTOM w0.102: v2(173.89,46.19) 173.55,46.53 173.55,46.86
  BOTTOM w0.127: 173.55,46.86 JDIM1.197
DIMM1_SA1: length 5.1
  TOP w0.127: v2(173.88,45.55) 174.04,45.55 174.47,45.97 v1(175.16,45.97) 175.16,46.28 174.78,46.66 R321.1
  BOTTOM w0.127: JDIM1.201 174.75,46.42 v2(173.88,45.55)
DMIC0: length 1.6
  TOP w0.127: U20.4 179.98,14.51 179.96,14.53 R405.2
DMIC_CLK_R: length 3.2
  TOP w0.127: R395.2 179.73,17.27 179.73,16.79 v2(179.83,16.7) 179.83,16.13 180.45,15.51 U20.2
DNBSWON#: length 280.2
  TOP w0.127: CN8.51 76.56,65.41 75.94,64.8 75.94,63.91 74.7,62.66 73.18,62.66 72.52,62 67.87,62 v1(66.83,63.04) 66.32,63.04 v2(65.81,62.54) ; R7469.2 170.96,75.62 171.27,75.31 v2(171.45,75.31) ; U11.21 37.56,70.13 37.86,69.84 39.15,69.84 40.31,68.68 40.77,68.68 41.13,69.05 v2(41.13,69.17) ; v2(174.72,64.54) 174.64,64.45 CN9.11
  IN1 w0.14: v2(100.13,29.92) 100.07,29.87 90.65,29.87 89.89,29.11 87.63,29.11 86.26,30.48 86.26,31.57 79.07,38.76 79.07,44.96 72.54,51.49 72.54,54.15 65.81,60.88 v2(65.81,62.54)
  IN2 w0.14: v2(106.04,17.6) 104.14,17.6 100.56,21.18 100.56,27.86 100.13,28.3 v2(100.13,29.92) ; v2(164.59,88.38) 164.8,88.17 165.65,88.17 166.14,87.68 166.14,87.05 167.27,85.92 167.27,84.49 168.89,82.87 168.89,78.24 169.89,77.25 169.89,76.08 170.66,75.31 v2(171.45,75.31) 171.45,74.5 171.98,73.97 171.98,72.06 173.56,70.48 175.34,70.48 176.02,69.81 176.02,65.83 v2(174.72,64.54)
  BOTTOM w0.076: v2(164.59,88.38) 164.23,88.74 U25.AL7
  BOTTOM w0.127: v2(41.13,69.17) 41.13,69.14 41.55,68.72 42.81,68.72 43.78,67.75 48.22,67.75 48.33,67.86 50.38,67.86 53.97,64.26 57.05,64.26 57.14,64.35 58.07,64.35 58.72,63.7 62,63.7 63.17,62.54 v2(65.81,62.54) ; v2(174.72,64.54) 174.27,64.08 174.27,63.55 175.55,62.26 175.81,62.26 176.07,62 176.07,61.22 177.51,59.78 178.63,59.78 180.44,57.97 180.44,46.21 182.07,44.59 182.07,26.71 177.01,21.66 173.78,21.66 173.08,20.96 167.35,20.96 166.12,19.72 165.72,19.72 165.16,19.17 165.16,19.17 164.8,18.81 162.13,18.81 161.06,17.74 153.84,17.74 153.04,18.54 147.16,18.54 147.16,18.54 146.52,18.54 143.41,18.54 141.49,16.62 121.69,16.62 118.25,13.18 109.07,13.18 106.09,16.15 106.09,17.55 v2(106.04,17.6)
DPWROK: length 11.5
  BOTTOM w0.076: 168.17,80.19 167.82,80.54 166.74,80.54 164.83,82.45 164.83,83.78 165.24,84.19 U25.AV5
  BOTTOM w0.127: 168.17,80.19 169.03,79.33 169.03,79.22 v2(169.22,79.04) 169.44,78.81 R579.1 169.44,77.92 170.19,77.17 170.58,77.17 171.03,76.72 R586.1
DPWROK_EC: length 247.1
  TOP w0.127: v2(49.67,73.36) 50.85,74.53 U11.87
  IN2 w0.14: v2(49.67,73.36) 49.67,72.32 54.66,67.34 54.66,64.31 54.94,64.03 54.94,62.37 57.07,60.24 57.07,58.84 58.2,57.71 61.99,57.71 63.68,56.02 63.69,56.02 67.61,52.1 67.61,50.96 76.78,41.78 76.78,40.1 84.64,32.24 84.73,32.24 89,27.97 89,26.11 90.23,24.88 90.23,15.12 88.99,13.88 88.99,10.6 90.55,9.04 114.68,9.04 115.21,9.58 115.21,11.35 115.09,11.48 v2(115.09,13.77)
  BOTTOM w0.127: v2(115.09,13.77) 118.12,13.77 121.48,17.13 141.23,17.13 143.15,19.05 146.31,19.05 153.25,19.05 154.05,18.25 158.31,18.25 160,19.94 162,19.94 162.62,19.32 164.59,19.32 164.85,19.58 164.86,19.58 165.51,20.23 165.91,20.23 167.14,21.46 172.87,21.46 173.57,22.16 176.8,22.16 181.56,26.92 181.56,44.38 179.93,46 179.93,57.7 178.36,59.28 177.3,59.28 176.69,59.89 174.59,59.89 169.95,64.52 169.95,74.18 170.76,74.99 170.76,75.45 R593.1 170.64,75.94 R586.2
DSW_WAKE#: length 1
  TOP w0.127: TP3.1 16.03,121.55 R143.2
DSWVRMEN: length 7
  BOTTOM w0.076: 163.73,81 163.71,81.01 163.71,82.54 163.5,82.75 163.5,83.24 U25.AW7
  BOTTOM w0.127: R576.1 166.27,78.44 v2(165.64,79.07) 165.31,79.39 164.88,79.39 163.73,80.54 163.73,81
EC_AOCS: length 220.8
  TOP w0.127: U11.84 53.24,73.33 53.49,73.58 53.49,75.73 55.41,77.65 56.79,77.65 58.63,79.49 58.99,79.49 v1(59.97,80.47) 61.5,82 64.56,82 65.18,82.62 65.18,85.56 63.88,86.87 63.88,93.08 64.71,93.92 79.02,93.92 96.29,111.18 96.29,114.1 103.1,120.9 106.55,120.9 109.14,118.32 117.33,118.32 117.93,118.92 127.93,118.92 128.96,119.95 131.6,119.95 132.96,121.31 133.63,121.31 v2(134.11,121.79) ; v2(189.64,76.31) 189.63,76.31 Q18.2
  IN1 w0.14: v2(181.95,102.06) 182.4,101.61 188.87,101.61 189.76,100.71 189.76,99.31 190.37,98.7 190.37,95.07 184.72,89.42 184.72,84.87 185.89,83.7 185.89,79.65 187.02,78.53 189.24,76.31 189.63,76.31 v2(189.64,76.31)
  IN2 w0.14: v2(181.95,102.06) 181.95,103.19 182.67,103.91 182.67,106.26 179.82,109.12 179.82,113.89 173.9,119.81 169.06,119.81 167.87,121.01 163.77,121.01 162.83,121.95 161.42,121.95 158.48,124.89 150.57,124.89 147.47,121.79 v2(134.11,121.79)
EC_PCIE_WAKE#: length 196.3
  TOP w0.127: Q4.3 170.69,154.51 171.21,153.98 EC13.1 170.1,153.7 v2(169.19,154.61) ; U11.79 53.3,71.33 53.48,71.51 53.48,71.91 53.76,72.19 53.76,72.43 54.51,73.18 54.51,73.84 55.64,74.97 R261.2 56.88,74.97 57.11,75.2 57.11,76.92 57.89,77.7 58.9,77.7 v1(59.18,77.98) 61.39,80.19 63.31,80.19 65.44,82.32 65.44,85.67 64.13,86.97 64.13,92.98 64.82,93.66 79.13,93.66 96.54,111.08 96.54,113.97 102.82,120.24 v2(104.29,120.24)
  IN1 w0.14: v2(130.76,122.61) 130.94,122.43 130.94,120.1 133.89,117.15 135.15,117.15 135.77,117.76 141.08,117.76 142.33,119.01 146.55,119.01 147.52,119.98 154.91,119.98 156.09,118.81 166.79,118.81 169.13,121.15 169.13,128.83 167.37,130.6 167.37,152.79 v2(169.19,154.61)
  IN2 w0.14: v2(130.76,122.61) 128.7,122.61 127.76,121.67 117.45,121.67 113.98,118.2 106.34,118.2 v2(104.29,120.24)
EC_PECI: length 120.5
  TOP w0.127: v2(94.36,73.86) 94.77,73.46 102.39,73.46 v1(106.58,77.65) 107.85,78.92 107.85,79.55 114.44,86.15 114.44,87.67 121.19,94.41 123.59,94.41 126.52,97.33 128.29,97.33 128.81,97.84 v2(128.81,98.02) ; R206.2 37.73,85.61 38.15,85.19 40.26,85.19 v2(40.76,84.7)
  IN1 w0.14: v2(69.24,62.69) 70.66,64.11 75.08,64.11 76.49,65.52 76.96,65.52 80.83,69.39 83.02,69.39 84.37,70.74 85.79,70.74 86.45,71.4 91.92,71.4 94.36,73.84 v2(94.36,73.86)
  BOTTOM w0.127: U25.N62 129.62,98.02 128.81,98.02 v2(128.81,98.02) ; v2(40.76,84.7) 43.58,81.88 43.84,81.88 50.59,75.13 50.59,71.53 55.15,66.97 57.44,66.97 58.93,65.47 62.21,65.47 63.72,63.96 67.3,63.96 68.21,63.04 68.88,63.04 v2(69.24,62.69)
EC_PECI_R: length 8.9
  TOP w0.127: R206.1 40.51,85.78 42.54,83.74 42.54,83.03 42.65,82.92 42.65,80.85 42.8,80.7 U11.117
EC_PWROK: length 318.4
  TOP w0.127: v2(66.7,61.9) 67.31,61.29 72.54,61.29 73.4,62.15 78.13,62.15 78.89,62.92 78.89,63.93 79.53,64.57 R290.1 C381.2 78.06,64.77 CN8.54 ; v2(167.8,81.5) 167.8,80.38 v2(167.24,79.82) 167.02,79.59 R240.2 C346.1 ; v2(40.5,69.21) 39.18,70.53 U11.20 35.96,70.53 35.54,70.11 v2(35.54,69.96) ; v2(31.71,89.48) 31.71,90.01 32.04,90.34 EC24.2 v1(32.54,89.23) 32.54,88.67 32.18,88.32 D6.1
  IN1 w0.076: 167.28,82.91 167.02,83.17 167.02,86.17 166.52,86.67 166.27,86.67 165.87,87.06 165.87,87.95 165.5,88.32 165.28,88.32 164.76,88.84 164.43,88.84 164.43,88.84 164.15,88.84 163.14,89.84 163.14,90.28 163.41,90.55 164.9,90.55 v2(166.27,91.92)
  IN1 w0.14: 167.28,82.91 167.8,82.39 v2(167.8,81.5) 167.8,81.22 169.85,79.17 169.85,78.84 170.48,78.2 170.62,78.07 171.69,78.07 174.52,75.24 175.74,75.24 176.86,74.12 176.86,71.33 177.73,70.46 177.73,67.95 177.39,67.62 177.39,66.87 178.41,65.85 178.41,62.91 179.74,61.58 179.74,56.3 179.35,55.91 179.35,48.26 179.7,47.9 179.7,42.42 178.91,41.63 178.91,29.52 174.26,24.87 169.71,24.87 169.04,24.21 169.04,24.21 168.71,23.88 165.05,23.88 164.81,23.63 127.77,23.63 127.42,23.28 121.81,23.28 121.42,22.89 121.05,22.89 120.79,23.15 118.97,23.15 118.44,23.67 111.86,23.67 111.25,24.28 109.27,24.28 107.44,26.11 100.96,26.11 100.84,26.24 83.77,26.24 82.81,27.19 82.81,29.65 75.26,37.2 75.26,42.77 68.73,49.3 68.73,52.7 58.95,62.48 57.65,62.48 v2(57.3,62.83)
  BOTTOM w0.076: U25.AY7 163.92,82.76 163.92,81.02 164.02,80.92 164.02,80.54 164.75,79.82 v2(167.24,79.82) ; U25.AB5 166.04,93.46 166.27,93.24 v2(166.27,91.92) 166.27,91.31 166.44,91.14 166.73,91.14 167.06,90.8 U25.AG2
  BOTTOM w0.127: v2(35.54,69.96) 35.54,69.7 34.92,69.07 34.38,69.07 32.26,71.2 32.26,72.97 30.88,74.35 30.88,78.43 31.01,78.56 31.01,79.7 31.42,80.1 31.42,89.19 v2(31.71,89.48) ; v2(40.5,69.21) 40.5,69.05 41.9,67.65 42.02,67.65 42.43,67.24 48.07,67.24 48.58,66.73 49.88,66.73 53.7,62.91 57.22,62.91 v2(57.3,62.83) 57.38,62.91 61.88,62.91 62.89,61.9 v2(66.7,61.9)
EC_RCIN#: length 269.9
  TOP w0.127: v2(178.59,75.46) 178.74,75.46 179.75,74.45 R269.1 ; U11.4 38.15,76.93 41.36,73.72 41.36,73.7 42.28,72.78 42.53,72.78 v2(44.83,70.49)
  IN1 w0.14: v2(165.46,93.94) 165.62,93.94 166.81,92.75 167.04,92.75 167.59,92.2 167.59,92.2 167.61,92.17 167.61,90.21 168.04,89.78 168.04,87.44 168.25,87.24 170.13,87.24 170.53,86.84 170.53,81.16 175.09,76.61 176.31,76.61 177.45,75.46 v2(178.59,75.46) 179.47,74.57 179.47,72.03 180.79,70.72 180.79,65.97 182.02,64.74 182.02,62.6 182.09,62.53 182.09,55.12 182.01,55.04 182.01,53.81 182.09,53.73 182.37,53.45 182.37,47.81 182.37,41.76 181.94,41.33 181.94,38.01 181.26,37.33 181.26,28.55 175.24,22.52 170.68,22.52 170.48,22.33 169.75,22.33 169.47,22.05 166.12,22.05 165.78,21.7 157.87,21.7 157.2,21.03 131.82,21.03 131.3,20.5 116.53,20.5 115.78,21.25 107.3,21.25 105.94,19.89 88.82,19.89 88.64,20.07 86.37,20.07 86.03,20.41 85.61,20.41 84.89,21.13 75.61,21.13 73.76,22.99 73.26,22.99 71.23,22.99 67.24,26.98 67.24,32.05 67,32.28 67,36.01 67.24,36.25 67.24,52.72 59.24,60.72 56.99,60.72 55.4,62.32 55.4,63.98 55.25,64.12 55.16,64.22 55.16,65.17 55.15,65.19 55.15,66.49 55.15,66.92 51.86,70.21 49.75,70.21 49.58,70.37 44.94,70.37 v2(44.83,70.49)
  BOTTOM w0.076: U25.V4 165.96,94.92 166.26,94.63 166.26,94.39 166.08,94.22 165.74,94.22 v2(165.46,93.94)
EC_RTC_RST: length 3.8
  TOP w0.127: v1(180.85,60.6) 180.86,60.62 R296.2 R293.1 180.24,62.54 179.98,62.79 Q19.2
EC_USB_CTRL1: length 39.6
  TOP w0.127: v2(28.9,71.83) 28.56,72.18 R275.2 ; v2(57.32,63.91) 56.84,63.42 R291.2
  IN1 w0.14: v2(57.32,63.91) 58.47,65.06 58.47,68.89 58.11,69.24 56.82,69.24 53.19,72.87 42.24,72.87 41.05,71.68 40.83,71.68 40.83,71.68 39.37,71.68 38.96,72.08 30.15,72.08 29.92,72.31 29.39,72.31 v2(28.9,71.83)
EC_USB_CTRL2: length 33.6
  TOP w0.127: U10.7 23.51,72.04 23.7,71.86 25.22,71.86 v1(25.47,72.11) v2(26.19,72.82) ; v2(47.52,73.97) 47.52,75.09 50.57,78.13 U11.96
  IN1 w0.14: v2(26.19,72.82) 29.79,72.82 30.26,72.35 39.08,72.35 39.48,71.95 40.94,71.95 42.13,73.14 46.7,73.14 v2(47.52,73.97)
EC_USB_CTRL3: length 30.7
  TOP w0.127: v2(26.82,73.58) 26.52,73.28 26.01,73.28 25.68,72.95 25.5,72.95 24.66,72.11 24.2,72.11 24.01,72.3 U10.8 ; v2(45.13,73.97) 45.13,75.11 41.6,78.64 U11.120
  IN1 w0.14: v2(45.13,73.97) 44.58,73.41 42.02,73.41 40.83,72.21 39.59,72.21 39.19,72.62 38.74,72.62 30.37,72.61 29.66,73.33 27.07,73.33 v2(26.82,73.58)
EC_WRST: length 52
  TOP w0.127: v2(40.1,76.69) 38.7,78.08 37.92,78.08 35.31,80.7 Q16.3 33.04,79.93 32.8,79.69 R237.2 C342.1 33.37,78.44 33.37,74.58 34.52,73.44 34.52,72.42 34.72,72.21 35.17,72.21 35.89,72.93 U11.14 ; v1(58.44,91.75) 58.32,91.87 56.31,91.87 56.03,91.59 Q15.3 56.03,85.12 v2(55.55,84.63)
  IN2 w0.14: v2(40.1,76.69) 41.06,77.65 51.59,77.65 55.55,81.61 v2(55.55,84.63)
EDP_DISP_UTIL: length 4.8
  BOTTOM w0.127: U25.A43 142.04,105.76 141.63,106.17 141.63,109.19 TP20.1
EDP_RCOMP: length 4.9
  TOP w0.508: v2(156.47,103.47) 156.41,103.53 155.95,103.53 155.19,102.77 v1(155.19,101.78) 155.19,100.02 R165.2
  BOTTOM w0.254: v2(156.47,103.47) 156.72,103.73 U25.D20
EMU_LID: length 117.4
  TOP w0.127: v2(55.5,76.68) 55.17,76.68 54.53,76.05 v1(54.53,74.85) 54.25,74.57 54.25,73.42 53.4,72.57 53.4,72.23 53.31,72.13 U11.81 ; v2(41.04,170.99) 41.05,170.98 R7.1
  BOTTOM w0.127: v2(41.04,170.99) 40.41,170.36 36.37,170.36 32.54,166.53 32.54,112.76 43.44,101.85 43.44,97.19 47.14,93.5 47.14,87.28 49.68,84.74 49.68,81.59 54.58,76.68 v2(55.5,76.68)
EXT_MIC_L: length 24.2
  TOP w0.254: v2(200.51,17.28) 200.48,17.25 CN14.5 ; R436.2 R435.2 185.32,6.27 v2(184.81,6.78) R430.2
  IN2 w0.254: v2(184.81,6.78) 184.81,7.29 185.19,7.67 188.01,7.67 193.95,13.61 195.96,13.61 199.17,16.83 200.06,16.83 v2(200.51,17.28)
FAN1_PWM: length 196.4
  TOP w0.127: v2(136.6,119.66) 136.6,120.56 134.41,122.75 134.41,123.59 133.69,124.31 131.7,124.31 127.46,120.07 117.88,120.07 116.48,121.46 116.48,124.46 113.38,127.56 107.06,127.56 94.38,114.88 94.38,111.98 78.23,95.82 57.78,95.82 55.97,97.63 47.62,97.63 36.48,108.76 28.26,108.76 27.61,108.12 27.61,98.45 v1(29.74,96.32) 30.66,95.4 30.66,79.22 31.45,78.43 31.45,75.61 33.91,73.15 33.91,66.4 34.5,65.81 35.29,65.81 36.01,66.53 U11.30
  BOTTOM w0.127: v2(136.6,119.66) 136.73,119.53 C703.1 137.37,116.28 137.37,119.79 137.42,119.84 FAN1.2
FAN1SIG: length 188.1
  TOP w0.127: v2(135.84,119.66) 135.84,120.78 134.03,122.59 134.03,123.43 133.53,123.93 132.36,123.93 131.21,122.78 131.21,121.21 130.73,120.73 128.66,120.73 127.62,119.69 117.72,119.69 116.1,121.31 116.1,124.3 113.22,127.18 107.31,127.18 94.77,114.63 94.77,111.82 78.39,95.44 52.46,95.44 50.66,97.24 47.46,97.24 42.93,101.78 37.54,101.78 34.68,98.92 31.88,98.92 v1(31.39,98.43) 31.04,98.07 31.04,81.89 31.41,81.52 35.18,81.52 38.37,78.34 39.08,78.34 40.54,76.87 40.54,76.36 45.62,71.29 45.62,69.34 45.12,68.85 45.12,68.01 44,66.89 U11.47
  BOTTOM w0.127: v2(135.84,119.66) 135.84,115.88 C702.1 R482.1 134.53,115.67 134.53,116.52 134.94,116.94 134.94,119.76 134.92,119.79 FAN1.4
GC6_FB_EN: length 28.6
  TOP w0.127: v2(164.2,96.8) 164.7,96.29 165.73,96.29 166.08,95.94 167.06,95.94 168.45,97.33 169.04,97.33 169.63,97.92 171.35,97.92 173.81,100.38 175.92,100.38 176.74,99.56 182.03,99.56 183.56,101.09 183.56,103.35 v1(183.82,103.61) 184,103.78 184,104.6 184.16,104.76 184.16,106.18 R139.1
  BOTTOM w0.089: v2(164.2,96.8) 163.98,96.58 U25.U7
GEN_XTAL25_IN: length 6.4
  TOP w0.127: Y3.1 73.79,83.48 C326.1 73.14,83.48 72.3,82.64 72.03,82.64 71.8,82.87 71.8,83.28 72.06,83.54 v1(72.06,84.09) 71.2,83.23 U9.1
GEN_XTAL25_OUT: length 6.4
  TOP w0.127: U9.16 72.16,81.59 72.97,82.4 v1(73.18,82.4) C337.1 73.57,81.34 73.86,81.64 75.14,81.64 Y3.3
GPIO13_ULT: length 18.6
  TOP w0.127: R218.1 180.1,84.26 v1(179.09,85.27) 178.15,86.22 178.15,86.69 177.28,87.55 176.95,87.55 176.81,87.41 172.23,87.41 169.85,85.02 v2(169.85,84.66)
  BOTTOM w0.076: 168.4,84.23 168.1,84.53 167.78,84.53 167.75,84.56 166.5,84.56 166.29,84.76 166.29,85.2 U25.AT3
  BOTTOM w0.127: v2(169.85,84.66) 169.42,84.23 168.4,84.23
GPIO14_ULT: length 13.9
  TOP w0.127: v2(173.23,90.45) 173.23,90.51 173.6,90.88 174.79,90.88 R183.1
  IN2 w0.14: v2(173.23,90.45) 173.44,90.24 173.44,90.2 173.63,90.02 173.63,88.94 173.14,88.46 171.74,88.46 170.54,89.65 166.84,89.65 166.27,90.22 v3(166.27,90.42)
  BOTTOM w0.076: U25.AH4 165.96,90.12 v3(166.27,90.42)
GPIO15_ULT: length 32.9
  TOP w0.127: v2(164.36,92.05) 164.87,92.56 165.63,92.56 165.89,92.81 165.89,92.99 166.75,93.85 167.22,93.85 168.04,94.67 170.44,94.67 v2(170.46,94.69) 170.51,94.69 171.16,95.34 172.12,95.34 173.66,96.88 174.45,96.88 174.81,96.52 178.5,96.52 178.64,96.66 182.85,96.66 185.29,99.1 R8560.1 186.71,99.12 187.22,99.63 187.22,104.83 R8561.2
  BOTTOM w0.127: U25.AD6 164.63,92.32 v2(164.36,92.05)
GPIO17: length 19.5
  IN2 w0.14: v2(180.11,98.48) 179.1,99.49 177.09,99.49 175.43,101.16 173.4,101.16 172.78,100.53 172.26,100.53 171.76,101.03 171.22,101.03 170.64,100.45 170.64,99.25 169.3,97.91 169.3,96.79 168.72,96.21 167.12,96.21 v3(166.91,96.42)
  BOTTOM w0.076: U25.T3 166.61,96.72 v3(166.91,96.42)
  BOTTOM w0.127: v2(180.11,98.48) 180.36,98.74 R513.1
GPIO25_ULT: length 13.8
  TOP w0.127: R173.1 174.28,94.41 173.3,94.41 172.61,93.73 172.61,92.64 170.83,90.86 169.19,90.86 168.3,89.97 167.66,89.97 167.41,89.71 167.41,88.7 166.91,88.2 v3(166.91,87.43)
  BOTTOM w0.076: v3(166.91,87.43) 166.38,87.43 U25.AM4
GPIO27: length 17.1
  TOP w0.127: v1(176.81,94.79) 176.69,94.91 R626.1 175.04,94.16 173.56,94.16 172.95,93.56 172.95,92.63 170.93,90.61 169.44,90.61 168.55,89.71 167.92,89.71 167.66,89.46 167.66,88.49 167.36,88.19 167.36,87.12 167.16,86.92 165.63,86.92 v2(165.45,87.1)
  BOTTOM w0.076: v2(165.45,87.1) 165.35,87.1 U25.AN5
GPIO33_EC: length 242.1
  TOP w0.127: D4.1 50.06,88.35 50.59,88.87 51.01,88.87 R191.2 51.59,88.34 v2(51.53,88.28)
  IN2 w0.14: v2(70.79,62.74) 70.79,62.73 73.44,60.07 73.44,58.81 80.34,51.92 80.34,49.94 86.7,43.58 86.7,41.97 86.69,39.9 89.97,36.63 91.44,36.63 92.2,35.87 92.56,35.51 92.56,34.85 94.67,32.73 94.67,32.58 95.68,31.57 97.64,31.57 99.13,30.07 99.13,28.5 99.92,27.71 99.92,21.08 104.06,16.94 106.35,16.94 106.73,17.32 v2(106.73,17.6)
  BOTTOM w0.127: v2(106.73,17.6) 106.73,17.2 107.83,16.09 107.83,15.92 108.18,15.57 109.43,15.57 109.44,15.58 109.81,15.58 109.82,15.57 114.78,15.57 117.65,18.44 140.36,18.44 141.98,20.07 145.89,20.07 153.67,20.07 154.47,19.27 157.89,19.27 159.58,20.96 164.79,20.96 165.08,21.25 165.49,21.25 166.72,22.48 172.45,22.48 173.15,23.18 176.38,23.18 179.93,26.73 179.93,44.57 178.92,45.58 178.92,51.05 178.56,51.41 176.81,51.41 176.25,51.97 174.26,51.97 162.96,63.26 162.96,74.35 161.69,75.62 R581.1 ; v2(51.53,88.28) 51.53,86.21 56.27,81.47 56.27,81.17 56.53,80.91 56.83,80.91 65.1,72.64 65.1,68.63 69.29,64.44 69.87,64.44 70.71,63.6 70.71,62.81 v2(70.79,62.74)
GPIO44_ULT: length 10.3
  BOTTOM w0.076: 169.42,89.64 169.29,89.76 167.62,89.76 167.45,89.59 166.78,89.59 166.72,89.66 166.28,89.66 U25.AK4
  BOTTOM w0.127: 169.42,89.64 169.54,89.51 171.65,89.51 172.06,89.92 172.6,89.92 172.93,89.59 173.3,89.59 173.42,89.46 173.63,89.46 v1(173.89,89.21) 174.14,89.46 175.15,89.46 R565.1
GPIO46_ULT: length 19.1
  IN2 w0.14: v2(182.08,93.9) 181.6,93.9 181.14,93.44 180.34,93.44 179.29,92.38 176.9,92.38 175.42,90.9 171.63,90.9 170.79,91.74 v3(170.39,91.74)
  BOTTOM w0.089: U25.AG3 166.98,90.48 167.38,90.48 167.59,90.68 167.59,90.98 167.82,91.21 169.49,91.21
  BOTTOM w0.127: 169.49,91.21 169.83,91.21 170.36,91.74 v3(170.39,91.74) ; v2(182.08,93.9) 181.25,94.72 R541.1
GPIO50_ULT: length 25.7
  TOP w0.127: v2(175.91,98.08) 175.98,98.02 182.3,98.02 184.47,100.19 184.47,102.46 v2(184.53,102.51) 184.88,102.86 184.88,104.26 185.02,104.4 185.02,104.92 R8562.2
  BOTTOM w0.076: U25.P3 166.75,97.51 167,97.25 168.95,97.25 169.05,97.35
  BOTTOM w0.127: 169.05,97.35 170.2,97.35 171.09,98.23 171.68,98.23 172.1,98.64 173.67,98.64 174.05,98.26 174.75,98.26 R524.1 175.42,97.59 v2(175.91,98.08)
GPIO52_ULT: length 11.7
  BOTTOM w0.089: 169.71,100.14 169.65,100.08 169.65,99.59 169.1,99.04 167.91,99.04 U25.L1
  BOTTOM w0.127: 169.71,100.14 171.3,101.73 172.93,101.73 174.56,100.1 v2(174.77,100.1) 174.98,100.3 176.53,100.3 176.96,99.87 R511.1
GPIO70_ULT: length 11.4
  BOTTOM w0.076: U25.C4 165.69,104.35 165.69,105.77
  BOTTOM w0.127: 165.69,105.77 165.69,105.9 166.17,106.38 166.17,108.67 168.81,111.31 v1(168.81,113.21) R486.1
GPIO76_ULT: length 10.4
  BOTTOM w0.127: R525.1 176.67,97.98 176.12,98.53 174.09,98.53 173.76,98.86 171.98,98.86 171.62,98.49 170.63,98.49 170.63,98.47 v2(169.98,97.82) 169.78,97.63 168.92,97.63 168.76,97.46 168,97.46 U25.P1
GPIO77_ULT: length 21.5
  IN2 w0.14: v2(180.76,98.53) 179.52,99.77 178.13,99.77 177.77,100.13 176.99,100.13 175.55,101.56 171.37,101.56 170.37,100.56 170.37,99.36 169.04,98.02 169.04,97.64 168.74,97.34 165.32,97.34 164.83,96.85 v2(164.83,96.79)
  BOTTOM w0.089: v2(164.83,96.79) 164.63,96.59 U25.U6
  BOTTOM w0.127: v2(180.76,98.53) 181.32,99.1 R514.1
GPU_EVENT#: length 7.6
  BOTTOM w0.076: 169.31,98.67 168.19,98.67 168.1,98.59 166.8,98.59 166.68,98.71 166.26,98.71 166.19,98.78 U25.L4
  BOTTOM w0.089: 169.31,98.67 169.88,99.24
  BOTTOM w0.127: 169.88,99.24 171.33,100.69 172.05,100.69 R510.1
GPUT_CLK: length 7.4
  TOP w0.127: U11.16 35.59,72.13 35.41,71.96 34.46,71.96 34.29,72.13 34.29,73.31 32.76,74.83 v1(32.76,75.18) 32.74,75.21 R260.2
GPUT_DATA: length 7.6
  TOP w0.127: R216.2 39.5,84.51 v2(39.52,84.48) 39.95,84.06 41.07,84.06 42.4,82.72 U11.118
GSPI0_CLK: length 21.8
  TOP w0.076: 165.99,99.75 165.99,99.68 165.88,99.58 165.88,99.44 165.67,99.23 164.82,99.23 v2(164.29,98.69)
  TOP w0.127: RP2.7 181.18,105.81 179.53,104.17 173.1,104.17 v1(172.49,103.56) 172.21,103.28 169.67,103.28 167.79,101.4 166.52,101.4 166.27,101.14 166.27,100.02 165.99,99.75
  BOTTOM w0.076: U25.L6 164.63,99.03 v2(164.29,98.69)
GSPI0_CS: length 16.4
  TOP w0.076: v3(164.84,97.76) 164.91,97.76 165.3,97.37 166.92,97.37 167.31,97.76 167.31,98.06
  TOP w0.127: 167.31,98.06 168.36,99.11 169.24,99.11 171.63,101.5 176.66,101.5 v2(177.29,100.86)
  BOTTOM w0.089: U25.R6 164.84,97.49 v3(164.84,97.76)
  BOTTOM w0.127: v2(177.29,100.86) 177.06,101.09 RP5.7
GSPI0_MISO: length 19
  TOP w0.076: v2(164.95,98.69) 165.32,99.06 165.86,99.06 166.04,98.88 166.27,98.88
  TOP w0.127: v2(179.49,100.86) 178.09,102.26 170.56,102.26 v1(170.2,101.91) 169.8,101.91 168.28,100.38 167.8,100.38 167.44,100.02 167.44,99.31 167.01,98.88 166.27,98.88
  BOTTOM w0.089: U25.N6 164.95,98.54 v2(164.95,98.69)
  BOTTOM w0.127: RP6.8 180.11,101.48 v2(179.49,100.86)
GSPI1_CLK: length 19.4
  TOP w0.127: v3(165.36,99.69) 166.01,100.34 166.01,101.27 166.39,101.65 167.66,101.65 169.54,103.53 171.41,103.53 172.31,104.44 179.2,104.44 180.54,105.78 RP2.6
  BOTTOM w0.089: 165.35,99.68 v3(165.36,99.69)
  BOTTOM w0.127: U25.L5 165.28,99.61 165.35,99.68
GSPI1_CS: length 18.1
  TOP w0.089: v3(163.55,97.74) 164.07,98.27 165.75,98.27 166.08,98.6
  TOP w0.127: 166.08,98.6 166.11,98.63 167.11,98.63 167.85,99.37 169.14,99.37 171.52,101.75 177.04,101.75 v2(177.93,100.86)
  BOTTOM w0.089: U25.R7 163.55,97.7 v3(163.55,97.74)
  BOTTOM w0.127: 177.7,101.82 177.7,101.09 v2(177.93,100.86)
GSPI1_MISO: length 20.3
  TOP w0.076: v2(164.18,97.75) 164.18,97.74 164.56,97.36 165.08,97.36 165.23,97.21 167.18,97.21 167.68,97.7 167.68,97.97
  TOP w0.127: v2(180.12,100.86) 179.68,100.42 177.1,100.42 176.27,101.24 173.43,101.24 172.56,100.38 171.27,100.38 v1(170.76,99.87) 169.75,98.86 168.57,98.86 167.68,97.97
  BOTTOM w0.089: v2(164.18,97.75) 163.98,97.96 U25.N7
  BOTTOM w0.127: RP6.7 180.74,101.48 v2(180.12,100.86)
GSPI1_MOSI: length 14.6
  TOP w0.127: v2(169.07,99.93) 169.07,100.27 v1(169.57,100.76) 170.08,100.76 171.33,102.01 177.71,102.01 v2(178.85,100.86)
  BOTTOM w0.076: 168.27,100.2 168.15,100.08 167.74,100.08 167.45,99.79 U25.K2
  BOTTOM w0.089: v2(169.07,99.93) 168.79,100.21 168.28,100.21 168.27,100.2
  BOTTOM w0.127: v2(178.85,100.86) 179.47,101.48 RP6.9
H_CPU_SVIDALRT#: length 6.2
  BOTTOM w0.127: R531.1 125.88,97.08 v1(126.01,97.21) 126.47,97.67 126.47,98.22 127.02,98.77 129.62,98.77 U25.L62
H_PROCHOT#: length 109.6
  TOP w0.127: v2(119.78,95.68) v1(118.39,94.29) 117.37,93.27 115.88,93.27 115.52,92.9 115.52,90.29 113.35,88.12 113.35,86.6 108.72,81.97 102.89,81.97 102,82.86 100.98,82.86 PR87.2 ; PR87.2 100.47,82.01 100.3,81.84 v2(99.85,81.84) ; PR87.2 PR86.2 ; v2(44.45,82.4) 44.25,82.6 44.25,84.3 39.52,89.03 C315.2 38.62,90.85 Q13.3
  IN1 w0.14: v2(99.85,81.84) 98.58,83.11 95.65,83.11 95.02,82.47 87.47,82.47 86.78,81.78 83.55,81.78 81.77,83.55 78.67,83.55 76.72,85.5 74.63,85.5 74.12,84.99 71.89,84.99 71.54,84.63 65.12,84.63 63.28,82.79 54.44,82.79 54.3,82.93 44.98,82.93 v2(44.45,82.4)
  BOTTOM w0.127: R517.1 124.09,99.13 123.11,98.15 122.63,98.15 122.58,98.1 R522.1 121.83,98.24 121.54,98.53 120.55,98.53 120.39,98.37 120.39,96.83 119.78,96.22 v2(119.78,95.68)
H_PROCHOT#_EC: length 15.5
  TOP w0.127: U11.124 40,80.55 39.85,80.7 39.2,80.7 37.76,82.14 37.18,82.14 36.46,82.86 R223.2 36.28,83.36 35.52,84.12 35.52,86.97 34.69,87.8 v1(34.69,90.35) 34.69,90.83 35.1,91.24 35.96,91.24
H_VCCST_PWRGD: length 92.7
  TOP w0.127: v2(113.16,93.37) 112.93,93.6 D2.2 114.15,94.84 v1(114.2,94.79) ; R289.1 74.56,65.26 v2(74.45,65.38)
  IN1 w0.14: v2(74.45,65.38) 75.29,66.22 76.81,66.22 80.58,69.99 82.77,69.99 84.53,71.75 85.83,71.75 86.08,72 91.58,72 93.5,73.91 v2(93.7,73.91)
  BOTTOM w0.076: 131.42,106.1 131.68,105.83 131.68,105.3 132.01,104.97 U25.B59
  BOTTOM w0.127: 131.42,106.1 130.76,106.76 128.88,106.76 127.58,108.05 126.24,108.05 124.94,106.76 119.18,106.76 118.31,105.89 118.31,102.97 115.75,100.41 115.75,98.02 113.82,96.1 C719.2 113.82,95.22 114.88,94.16 R557.1 114.23,93.37 v2(113.16,93.37) 112.19,93.37 111.29,92.47 111.29,87.33 108.27,84.32 104.21,84.32 102.58,82.69 102.58,79.39 99.95,76.76 96.41,76.76 93.7,74.05 v2(93.7,73.91)
H_VR_ENABLE_MCP: length 53.3
  TOP w0.127: PR91.2 99.28,80.25 107.72,80.25 113.86,86.39 113.86,87.91 116.1,90.15 v1(116.1,91.62) 116.1,92.62 v2(116.03,92.69)
  IN2 w0.14: v2(130.94,102.45) 130.94,102.49 130.5,102.92 128.7,102.92 128.47,103.15 119.66,103.15 v2(119.33,103.48)
  BOTTOM w0.127: v2(116.03,92.69) 116.76,93.43 116.76,99.98 119.33,102.54 v2(119.33,103.48) 119.33,105.38 119.68,105.74 120.77,105.74 R494.2 ; U25.F60 131.24,102.16 v2(130.94,102.45)
HD_SDIN0: length 3.9
  TOP w0.127: R410.2 177.6,11.89 179.58,11.89 180.2,12.51 U20.8
HDMI_DET_C: length 16.7
  TOP w0.127: v1(17.55,95.58) 18.77,94.36 Q10.3 18.02,93.46 R176.2 C298.1 VC1.1 15.37,92.48 v2(15.24,92.35)
  IN1 w0.14: v2(15.24,92.35) 15.24,89.69 CN24.19
HDMI_HPD_CON: length 205.2
  TOP w0.127: Q10.1 22.6,95.38 R170.1 26.4,95.39 27.2,96.19 v1(27.2,97.33) 27.2,108.25 28.1,109.14 36.64,109.14 47.78,98.01 56.13,98.01 57.81,96.33 78.2,96.33 94,112.13 94,115.37 103.12,124.49 103.12,124.97 103.39,125.23 v2(103.78,125.23)
  IN1 w0.14: v2(165.31,120.46) 164.19,119.34 156.31,119.34 155.13,120.52 147.3,120.52 146.33,119.55 141.77,119.55 140.54,118.32 133.52,118.32 131.67,120.17 v2(131.67,121.46)
  IN2 w0.14: v2(103.78,125.23) 103.78,119.91 105.76,117.93 114.09,117.93 117.16,121.01 131.21,121.01 v2(131.67,121.46)
  BOTTOM w0.076: U25.C8 163.7,104.32 164.13,104.75 164.13,104.9 164.49,105.26 164.49,106.63
  BOTTOM w0.127: 164.49,106.63 165.12,107.26 165.12,120.27 v2(165.31,120.46)
HDMI_SCLK: length 19.2
  TOP w0.127: CN24.15 10.87,83.32 10.87,84.61 13.96,87.7 14.34,87.7 v1(14.82,88.18) 14.82,88.17 15.11,87.88 15.64,87.88 15.77,88.01 C318.1 16.4,87.94 16.79,87.94 17.03,88.18 R196.2 17.64,87.96 22.37,87.96 23.2,87.13 Q14.3
HDMI_SDATA: length 25.6
  TOP w0.127: CN24.16 11.1,83.9 11.1,84.52 14.05,87.47 14.26,87.47 v1(14.82,86.91) 14.82,87.24 15.24,87.66 15.64,87.66 15.77,87.53 C321.1 16.42,87.71 16.8,87.71 17.03,87.48 R202.2 17.72,87.73 22.27,87.73 23.1,86.9 23.57,86.9 23.66,86.82 25.53,86.82 25.59,86.75 27.72,86.75 28.12,87.15 28.12,88.14 27.82,88.43 Q14.6
HOLD#: length 5.7
  BOTTOM w0.127: TP29.1 185.69,100.64 R504.2 186.47,102.43 R500.2 186.47,102.91 184.94,104.45 U24.7 U23.7
HP_EAPD: length 34.6
  TOP w0.127: U20.48 181.68,17.38 180.71,18.35 v2(180.71,19.18)
  BOTTOM w0.127: v2(180.71,19.18) 180.71,19.93 v1(183.28,22.5) 184.59,23.81 185.37,23.81 185.4,23.84 190.08,23.84 190.45,24.21 200.63,24.21 201.84,23 201.86,23 202.61,22.25 202.61,16.59 D13.1
HPOUT_L: length 17.8
  TOP w0.254: C545.2 191.92,21.27 191.91,21.26 ; R624.1 v2(190.14,13.01) v1(189.63,13.51) 189.48,13.67 188.65,13.67 188.49,13.51 U20.31 ; 191.91,21.26 191.91,21.5 v2(191.44,21.97) ; 191.91,21.26 R387.1
  IN2 w0.254: v2(191.44,21.97) 191.91,21.5 191.91,18.77 189.63,16.5 189.63,14.4 189.51,14.28 189.51,13.64 v2(190.14,13.01)
  BOTTOM w0.254: C797.2 190.78,21.31 v2(191.44,21.97) ; v2(190.14,13.01) R616.2
HPOUT_L_1: length 3.4
  BOTTOM w0.254: C797.1 191.29,19.85 191.73,19.85 192.12,19.46 193.46,19.46 193.59,19.34 U28.1
HPOUT_R: length 27.8
  TOP w0.254: C546.2 194.84,21.27 R388.1 195.55,21.73 v2(195.55,21.84) ; R625.1 191.07,14.07 v2(190.12,14.07) 188.56,14.07 188.5,14.01 U20.32
  IN2 w0.254: v2(190.12,14.07) 190.4,14.35 190.4,16.18 194.59,20.37 194.59,20.75 195.55,21.72 v2(195.55,21.84)
  BOTTOM w0.254: C800.2 195.98,21.26 195.55,21.69 v2(195.55,21.84) ; R617.2 198.66,12.37 198.45,12.16 189.97,12.16 v1(189.89,12.24) 189.51,12.62 189.51,13.46 v2(190.12,14.07)
HPOUT_R_1: length 2.5
  BOTTOM w0.254: v1(196.94,20.3) 196.75,20.49 C800.1 195.59,20.1 U28.5
