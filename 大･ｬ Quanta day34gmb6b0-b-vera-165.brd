# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SDIO_D2: length 20.3
  TOP w0.127: v3(168.03,105.07) 168.56,104.55 170.94,104.55 171.85,105.46 176.06,105.46 178.99,108.4 178.99,108.76 179.91,109.68 182.01,109.68 183.08,108.61 RP2.1
  BOTTOM w0.076: U25.C3 167,104.6 167.56,104.6 v3(168.03,105.07)
SDIO_D3: length 17.4
  BOTTOM w0.076: U25.E2 167.46,102.59 168.04,102.59 168.08,102.63
  BOTTOM w0.127: RP6.4 180.74,103.85 179.58,105.02 178.02,105.02 177.87,105.16 177.87,106.3 v1(177.7,106.48) 177.57,106.6 172.08,106.6 168.11,102.63 168.08,102.63
SDVO_CLK: length 168.2
  TOP w0.127: Q14.4 25.72,87.13 25.53,87.33 25.53,88.75 25.7,88.93 25.7,89.59 25.92,89.81 R188.2 25.68,90.54 25.68,91.55 26.13,92 27.18,92 v1(27.71,91.47) 28.24,92 29.54,92 v2(29.79,91.75)
  IN1 w0.14: v2(163.61,108.48) 163.33,108.76 152.29,108.76 151.99,108.46 144.35,108.46 143.03,107.14 141.72,107.14 141.04,107.82 128.42,107.82 126.93,109.31 126.93,112.34 124.77,114.5 118.66,114.5 116.82,112.66 110.45,112.66 108.47,114.64 104.07,114.64 80.85,91.43 69.02,91.43 67.64,90.04 56.96,90.04 56.56,89.65 37.83,89.65 37.01,90.47 33.22,90.47 31.69,92 30.05,92 v2(29.79,91.75)
  BOTTOM w0.076: U25.B9 162.33,104.73 162.43,104.73 162.57,104.87 162.57,105.14 162.83,105.4 162.83,105.62 163.55,106.34 163.55,107.3 163.88,107.63 163.88,108.2 v2(163.61,108.48)
SDVO_DATA: length 168.3
  TOP w0.127: v2(29.79,92.51) 29.51,92.23 28.22,92.23 v1(27.71,92.74) 27.2,92.23 26.03,92.23 25.45,91.64 25.45,90.49 R187.2 25.28,89.81 25.47,89.61 25.47,89.02 25.3,88.84 25.3,88.59 25.14,88.43 Q14.1
  IN1 w0.14: v2(164.36,108.5) 164.17,108.7 163.83,109.03 152.18,109.03 151.88,108.72 144.24,108.72 142.92,107.41 141.83,107.41 141.15,108.09 128.53,108.09 127.2,109.42 127.2,112.45 124.88,114.77 118.55,114.77 116.71,112.93 110.56,112.93 108.58,114.91 103.96,114.91 80.74,91.69 68.91,91.69 67.53,90.31 56.85,90.31 56.45,89.92 37.94,89.92 37.12,90.74 33.33,90.74 31.8,92.27 30.03,92.27 v2(29.79,92.51)
  BOTTOM w0.076: v2(164.36,108.5) 164.05,108.18 164.05,107.56 163.72,107.23 163.72,106.27 163,105.55 163,105.33 162.73,105.07 162.73,104.8 162.56,104.63 U25.C9
SENSE_A: length 26
  TOP w0.254: CN14.7 199.78,18.25 v2(200.2,17.83) ; v2(181.51,6.78) R428.2
  IN2 w0.254: v2(200.2,17.83) 199.1,17.83 196,14.73 193.99,14.73 187.81,8.56 183.28,8.56 v2(181.51,6.78)
  BOTTOM w0.254: v2(181.51,6.78) v1(182.39,6.78)
SENSE_A_1: length 1.5
  TOP w0.254: U20.13 181.68,8.91 181.51,8.74 R428.1
SERIRQ: length 308.5
  TOP w0.127: U11.5 37.84,76.53 v2(37.92,76.45) ; v2(80.97,17.53) 81.28,17.83 81.28,22.17 82.01,22.91 82.01,23.93 82.54,24.45 U18.27 84.5,24.45 84.91,24.87 v1(84.91,26.34)
  IN1 w0.14: v2(80.97,17.53) 81.35,17.15 81.71,17.15 82.54,16.31 91.55,16.31 91.91,16.68 98.82,16.68 99.44,17.3 104.66,17.3 105.37,16.59 108.96,16.59 110.58,18.21 119.61,18.21 120.08,17.74 134.18,17.74 135.17,18.73 160.1,18.73 160.34,18.5 165.37,18.5 165.82,18.05 166.52,18.05 166.81,17.75 169.25,17.75 171.72,20.23 176.19,20.23 183.25,27.28 183.56,27.59 183.56,30.15 184.89,31.48 184.89,35.53 185.43,36.07 185.43,43.07 187.37,45.01 187.37,52.26 189.86,54.75 189.86,58.53 185.27,63.13 185.27,65.12 183.43,66.97 183.43,75.93 181.56,77.8 181.56,82.1 179.79,83.86 179.79,84.98 178.39,86.38 178.39,86.86 177.37,87.88 177.37,90.61 176.86,91.12 176.86,93.07 178.99,95.2 180.06,95.2 180.62,95.76 180.63,95.76 180.89,96.03 180.89,96.03 v2(181.07,96.22)
  IN2 w0.14: v2(166.26,96.42) 166.78,95.9 167.92,95.9 168.41,95.41 170.47,95.41 170.73,95.67 170.73,96.05 170.51,96.26 170.51,96.89 170.76,97.14 172.93,97.14 173.32,97.52 173.32,99.53 173.51,99.73 174.69,99.73 175.89,98.53 177.84,98.53 179.15,97.23 180.09,97.23 180.62,96.69 180.63,96.69 180.89,96.43 180.89,96.43 v2(181.07,96.22) ; v2(80.97,17.53) 81.28,17.83 81.28,18.31 83.08,20.12 83.08,26.16 81.08,28.17 81.08,28.99 68.49,41.58 68.49,41.89 66.18,44.2 63.11,44.2 60.9,46.42 60.9,48.35 58,51.25 54.12,55.13 52.72,55.13 48.55,59.3 47.27,60.58 47.04,60.58 46.49,61.14 44.49,61.14 44.1,61.53 41.26,64.36 39.77,64.36 36.88,67.25 36.88,75.42 v2(37.92,76.45)
  BOTTOM w0.089: U25.T4 166.26,96.53 v2(166.26,96.42)
  BOTTOM w0.127: v2(181.07,96.22) 181.35,96.51 181.78,96.51 182.21,96.94 R529.1
SIO_EXT_SCI#: length 259.4
  TOP w0.127: v2(41.71,70.45) 41.65,70.39 41.65,68.84 40.98,68.17 40.1,68.17 38.94,69.33 U11.23 ; v1(180.11,71.32) 180.01,71.43 v2(179.35,71.43) 179.35,71.12 178.64,70.41 R282.1
  IN1 w0.14: v2(108.21,20.24) 106.9,18.92 91.58,18.92 91.28,18.62 86.46,18.62 85.63,19.44 83.75,19.44 83.12,20.08 73.4,20.08 66.86,26.63 65.93,26.63 63.36,29.19 63.36,32.89 62.84,33.41 62.84,39.32 63.04,39.52 63.04,40.66 63.71,41.33 63.71,41.71 63.04,42.38 63.04,42.51 62.77,42.78 62.77,43.67 62.76,43.68 62.76,51.62 62.76,51.62 62.76,51.84 58.85,55.75 58.85,57.96 58.07,58.74 58.07,59.64 57.81,59.91 56.91,59.91 54.87,61.94 54.87,63.76 54.64,64 54.64,64.96 54.63,64.97 54.63,66.71 51.65,69.69 49.54,69.69 49.37,69.85 44.65,69.85 44.05,70.45 v2(41.71,70.45) ; v2(169.21,84.66) 169.82,84.04 169.82,81.22 174.9,76.15 176.12,76.15 177.69,74.57 177.97,74.57 178.9,73.64 178.9,71.87 v2(179.35,71.43) 180.27,70.5 180.27,65.76 181.38,64.65 181.38,62.53 181.57,62.34 181.57,55.33 181.38,55.14 181.38,48.82 181.76,48.43 181.76,41.89 181.42,41.55 181.42,38.22 180.74,37.55 180.74,28.76 175.02,23.04 v2(172.29,23.04)
  BOTTOM w0.076: U25.AU2 167.58,85.19 168.07,85.19 168.21,85.05 168.81,85.05 v2(169.21,84.66)
  BOTTOM w0.127: v2(108.21,20.24) 108.65,20.68 114.55,20.68 116.33,18.9 139.37,18.9 140.82,20.35 153.75,20.35 154.58,19.52 156.77,19.52 157.6,20.35 157.66,20.35 158.52,21.21 164.16,21.21 164.72,21.77 165.28,21.77 166.28,22.77 171.76,22.77 171.95,22.96 172.2,22.96 v2(172.29,23.04)
SIO_EXT_SMI#: length 289.5
  TOP w0.127: U11.15 37.6,72.53 38.65,71.48 38.93,71.48 39.48,70.94 42.31,70.94 43.1,70.16 43.1,69.06 v2(43.97,68.19)
  IN1 w0.14: v2(180.44,96.22) 180.26,96.03 180.26,96.03 179.99,95.76 179.99,95.76 179.69,95.47 178.88,95.47 176.22,92.81 176.22,88.65 178.12,86.75 178.12,86.21 179.53,84.81 179.53,83.75 181.29,81.99 181.29,77.14 183.16,75.27 183.16,66.85 185,65.01 185,63.02 189.58,58.44 189.58,54.85 187.1,52.37 187.1,45.12 185.16,43.18 185.16,36.18 184.62,35.65 184.62,31.61 183.29,30.28 183.29,27.71 183.14,27.55 183.14,27.55 176.08,20.49 171.61,20.49 169.14,18.02 166.92,18.02 166.63,18.32 165.93,18.32 165.27,18.97 162.41,18.97 161.75,19.63 159.94,19.63 159.31,19 135.06,19 134.53,18.47 110.47,18.47 108.85,16.85 105.48,16.85 104.77,17.56 98.03,17.56 97.72,17.25 85.45,17.25 85.3,17.39 81.94,17.39 81.28,18.06 80.59,18.06 79.47,16.94 73.34,16.94 68.91,21.37 68.91,22.58 66.77,24.71 65.95,24.71 61.69,28.97 61.69,29.36 61.07,29.99 61.07,51.65 57.48,55.24 57.48,57.45 53.82,61.11 53.54,61.39 53.54,63.21 52.94,63.81 52.63,64.12 52.63,65.66 50.72,67.56 49.01,67.56 48.71,67.86 47.28,67.86 46.49,68.66 44.44,68.66 v2(43.97,68.19)
  IN2 w0.14: v3(170.97,96.65) 171.12,96.5 171.12,95.91 171.37,95.66 172.39,95.66 172.66,95.39 173.97,95.39 175.32,96.74 178.59,96.74 178.81,96.96 179.72,96.96 179.99,96.69 179.99,96.69 180.26,96.43 180.26,96.43 v2(180.44,96.22)
  BOTTOM w0.127: U25.U1 168.08,96.05 168.24,95.89 168.82,95.89 169.38,96.44 170.76,96.44 v3(170.97,96.65) ; v2(180.44,96.22) 181.14,96.94 181.5,96.94 R528.1
SLP_A#: length 34.2
  TOP w0.127: CN9.6 173.71,66.95 174.45,67.69 175.64,67.69 176.01,68.06 176.45,68.5 177.09,69.14 v2(177.27,69.14)
  IN2 w0.14: v2(165.47,88.98) 165.63,88.98 166.13,88.47 167.11,88.47 167.66,87.92 167.66,87.68 168.15,87.2 169.92,87.2 170.38,86.74 170.38,84.18 170.06,83.85 170.06,79.26 169.84,79.04 169.84,78.42 170.68,77.57 170.68,76.64 171.22,76.1 171.77,76.1 172.24,75.64 172.24,75.11 172.78,74.56 172.78,72.66 174.01,71.43 176.3,71.43 177.27,70.45 v2(177.27,69.14)
  BOTTOM w0.076: 165.05,88.74 165.24,88.74 165.47,88.97 v2(165.47,88.98)
  BOTTOM w0.089: U25.AL5 165.05,88.74
SLP_S5#: length 28.1
  TOP w0.127: CN9.4 173.84,67.95 174.28,68.39 v2(175.03,68.39)
  IN2 w0.14: v2(175.03,68.39) 175.5,68.85 175.5,69.23 175.14,69.58 174.57,69.58 174.37,69.77 173.37,69.77 168.69,74.46 168.69,75.69 169.37,76.37 169.37,77.03 167.89,78.51 167.89,79.03 168.3,79.44 168.3,82.24 166.37,84.17 166.37,85.12 165.63,85.85 165.25,85.85 165.02,86.08 165.02,86.67 v2(164.6,87.1)
  BOTTOM w0.076: U25.AP5 164.91,86.79 v2(164.6,87.1)
SLP_SUS#_EC: length 232
  TOP w0.127: v2(48.41,74.19) 49.63,75.42 51.34,75.42 51.66,75.73 U11.90
  IN1 w0.14: v2(165.46,86.38) 166.51,86.38 166.75,86.14 166.75,82.93 167.38,82.3 167.38,81.26 169.62,79.02 169.62,78.74 170.52,77.84 171.59,77.84 173.79,75.64 173.79,73.4 176.79,70.39 176.79,66.74 177.86,65.67 177.86,62.73 179.22,61.37 179.22,56.62 178.64,56.03 178.64,48.23 179.18,47.69 179.18,42.63 178.39,41.84 178.39,29.74 174.05,25.39 169.49,25.39 168.82,24.73 168.49,24.4 164.83,24.4 164.59,24.16 127.56,24.16 127.2,23.8 121.69,23.8 121.3,24.19 112.08,24.19 111.29,24.98 109.95,24.98 107.27,27.66 91.59,27.66 91.41,27.48 v2(90.96,27.48) 90.75,27.28 87.24,27.28 84.63,29.89 84.63,30.4 77.45,37.59 77.45,43.91 70.76,50.6 70.76,53.29 61.1,62.95 61.1,64.6 59,66.7 59,70.49 57.81,71.68 55.13,71.68 53.48,73.34 53.13,73.69 50.47,73.69 49.96,74.2 48.42,74.2 v2(48.41,74.19)
  BOTTOM w0.076: U25.AP4 165.92,86.38 v2(165.46,86.38)
SLP_SUS_ON: length 282.5
  TOP w0.127: v2(48.99,66.09) 48.99,72.27 48.41,72.86 48.41,73.56 50.01,75.16 51.41,75.16 51.58,75.33 U11.89
  IN1 w0.14: v2(48.99,66.09) 49.02,66.07 50.52,66.07 50.83,65.76 50.83,65.73 51.28,65.28 51.28,61.66 56.4,56.54 56.4,54.67 60,51.07 60,28.88 60.25,28.63 60.25,27.61 72.93,14.92 80.99,14.92 81.31,14.6 89.59,14.6 90.74,13.45 94.98,13.45 96.02,12.41 108.34,12.41 111.36,15.42 114.25,15.42 115.83,13.84 139.09,13.84 140.98,15.74 153.32,15.74 153.58,16 162.37,16 162.87,15.5 163.03,15.34 165.69,15.34 165.78,15.25 168.57,15.25 169.11,14.71 v2(169.11,14.61) ; v2(189.91,34.14) 189.77,34.28 189.77,37.94 189.47,38.24 189.46,38.24 188.81,38.89 188.81,41.59 192.87,45.65 192.87,49.86 193.41,50.4 193.41,52.17 193.41,52.39 194.22,53.2 194.22,56.43 193.46,57.19 193.46,58.84 192.07,60.22 192.07,68.61 191.06,69.62 191.06,76.15 191.22,76.31 v2(191.22,77.24)
  BOTTOM w0.127: U26.3 181.17,92.86 C724.2 181.13,92.63 181.46,92.3 181.46,91.42 R563.2 182.46,90.42 182.46,83.3 v1(182.9,82.86) 183.32,82.43 183.32,82.13 183.77,81.69 184.83,81.69 186.02,80.51 190.21,80.51 191.01,79.71 191.01,77.46 v2(191.22,77.24) ; v2(169.11,14.61) 169.16,14.55 170.58,14.55 171.16,13.98 171.16,13.58 171.76,12.97 175.5,12.97 177.23,14.7 178.41,14.7 179.31,15.6 179.31,15.6 180.01,16.29 180.01,17.81 179.24,18.58 179.24,21.68 186.1,28.53 186.1,29.33 189.91,33.15 v2(189.91,34.14)
SM_INTRUDER#: length 10.1
  BOTTOM w0.076: U25.AU6 164.58,84.6 164.88,84.29 164.88,84.06 164.65,83.83 164.35,83.83 164.08,83.56 164.08,81.85 164.57,81.37 165.02,81.37 166.17,80.21 167.4,80.21 167.66,79.95 167.66,79.68
  BOTTOM w0.127: R577.2 167.28,79.09 v2(167.29,79.09) 167.66,79.47 167.66,79.68
SM_RCOMP_0: length 10.1
  TOP w0.305: R251.1 128.96,79.53 130.99,81.57 130.99,82.3 131.02,82.33 131.02,82.35 131.95,83.28 131.95,84.63 v3(131.25,85.34)
  BOTTOM w0.305: U25.AU60 131.35,85.24 v3(131.25,85.34)
SM_RCOMP_1: length 8.5
  TOP w0.305: R250.1 127.94,80.04 129.85,81.94 129.85,82.98 v3(130.87,84)
  BOTTOM w0.305: U25.AV60 131.06,84.19 v3(130.87,84)
SM_RCOMP_2: length 9.9
  TOP w0.305: R249.1 126.93,80.57 128.73,82.37 v1(128.73,83.11) 128.73,83.87 v2(130.16,85.31)
  BOTTOM w0.305: v2(130.16,85.31) 130.35,85.11 U25.AU61
SM_VREF: length 134.1
  TOP w0.203: 137.21,84.86 137.21,86.03 137.53,86.35 v2(137.7,86.35) 137.87,86.35 138.17,86.05 138.17,85.01
  TOP w0.508: v2(109.17,46) 109.17,62.72 118.08,71.63 132.46,71.63 136.88,76.05 136.88,76.96 v1(136.93,77.01) 137.35,77.43 137.35,84.01 ; v2(123.82,21.87) 123.82,20.02 124.56,19.28 149.27,19.28 151.05,21.06 151.05,22 152.35,23.29 152.35,24.75 152.67,25.07 C540.1 152.67,26.28 R380.1
  BOTTOM w0.254: v2(137.7,86.35) 137.83,86.35 138.12,86.65 U25.AP49
  BOTTOM w0.508: v2(123.82,21.87) 123.49,22.2 120.85,22.2 119.63,23.42 113.35,23.42 112.03,24.74 112.03,31.05 109.17,33.91 v2(109.17,46)
SMB_ME0_CLK: length 11.4
  BOTTOM w0.076: 168.87,87.05 168.78,87.13 167.99,87.13 U25.AN1
  BOTTOM w0.127: 168.87,87.05 170.28,87.05 170.86,87.62 172.58,87.62 v1(172.85,87.88) 173.11,87.62 178,87.62 R569.2
SMB_ME0_DAT: length 11.3
  BOTTOM w0.127: U25.AK1 168.91,89.3 169.24,88.97 171.35,88.97 v1(171.75,88.57) 171.91,88.42 173.05,88.42 173.59,87.88 178.39,87.88 R568.2
SMB_ME1_CLK: length 37.3
  IN2 w0.14: v2(177.67,86.45) 176.95,86.45 176.15,87.25 176.15,89.92 177.42,91.19 179.53,91.19 180.8,92.46 182.73,92.46 184.61,94.33 184.61,95.07 185.14,95.61 186.41,95.61 186.71,95.91 186.71,96.42 185.58,97.55 v2(185.58,98.59)
  BOTTOM w0.076: U25.AU3 166.95,85.22 166.95,85.73 167.07,85.85 168.84,85.85 169,85.69
  BOTTOM w0.127: Q38.3 184.75,98.03 185.3,98.59 v2(185.58,98.59) ; 169,85.69 169.11,85.57 170.28,85.57 171.31,86.61 176.89,86.61 177.03,86.46 177.65,86.46 v2(177.67,86.45) 179.08,85.03 R572.2
SMB_ME1_DAT: length 25.9
  TOP w0.127: v2(184.86,96.19) 184.86,96.04 185.39,95.5 v1(185.85,95.5)
  IN2 w0.14: v2(184.86,96.19) 184.86,96.06 184.05,95.25 184.05,94.53 183.75,94.23 183.08,94.23 182.7,93.85 182.7,93.52 182.15,92.98 180.58,92.98 179.42,91.82 177.37,91.82 v2(177.32,91.87)
  BOTTOM w0.076: 169.56,90.21 168.17,90.21 168.03,90.34 167.76,90.34 167.62,90.2 167.62,90 167.38,89.76 166.87,89.76 U25.AH3
  BOTTOM w0.127: Q38.6 185.15,96.73 184.86,96.44 v2(184.86,96.19) ; 169.56,90.21 169.72,90.37 170.28,90.37 170.98,91.07 174.04,91.07 174.65,91.69 176.51,91.69 176.95,91.25 R560.2 177.44,91.75 v2(177.32,91.87)
SMB_PCH_CLK: length 18
  TOP w0.127: v2(178.94,89.97) 179.03,90.05 Q12.6
  IN2 w0.14: v2(177.18,87.03) 177.18,88.91 178.23,89.97 v2(178.94,89.97)
  BOTTOM w0.076: U25.AP2 167.56,86.01 169.98,86.01
  BOTTOM w0.127: 169.98,86.01 171.08,87.11 177.1,87.11 v2(177.18,87.03) 177.8,87.03 178.81,86.03 R570.2
SMB_PCH_DAT: length 19.6
  TOP w0.127: v2(182.41,91.92) 182.02,91.53 Q12.3 183.09,91.35 v1(183.34,91.11)
  IN2 w0.14: v2(176.71,89.19) 176.71,89.63 177.57,90.49 180.15,90.49 180.62,90.96 181.1,91.45 181.36,91.7 181.57,91.92 182.4,91.92 v2(182.41,91.92)
  BOTTOM w0.127: R566.2 176.74,89.21 v2(176.71,89.19) 176.71,89.58 176.45,89.84 173.58,89.84 173.42,90 173.05,90 172.76,90.3 170.94,90.3 170.64,89.99 167.97,89.99 U25.AH1
SMB_RUN_CLK: length 317.1
  TOP w0.127: v2(179.58,89.48) 179.98,89.08 R194.2 180.23,89.48 180.44,89.69 180.69,89.69 181.06,90.05 Q12.1 ; v2(68.17,22.61) 68.17,23.48 74.54,29.85 79.13,29.85 87.4,38.12 87.4,50.85 85.41,52.84 85.41,54.32 87.27,56.18 v1(87.27,58.09) 87.27,59 87.45,59.17 87.45,61.49 86.97,61.98 86.97,63.58 85.12,65.43 80.04,65.43 79.56,65.91 CN8.57 ; v2(151.66,17.12) 151.66,17.22 153.97,19.53 153.97,20.72 155.23,21.97 155.8,21.97 v2(156.11,21.67) 156.41,21.97 158.02,21.97 158.02,21.97 158.72,21.97 158.72,21.97 160.48,21.97 160.81,21.64 160.81,20.5 161.07,20.23 Q27.4
  IN1 w0.14: v2(179.58,89.48) 179.58,87.07 180.3,86.34 180.51,86.34 181.62,85.24 181.62,83.72 181.71,83.62 181.71,83.62 182.82,82.51 182.82,78.21 184.61,76.42 184.61,67.46 186.22,65.85 186.42,65.65 187.79,65.65 189.92,63.51 189.92,60.5 192.14,58.29 192.14,53.64 190.24,51.74 190.24,49.6 191.07,48.77 191.07,45.69 186.84,41.47 186.84,34.44 186.07,33.67 186.07,30.99 185.69,30.61 185.69,28.06 183.74,26.1 182.34,24.71 182.34,23.27 180.8,21.72 180.5,21.72 176.79,18.01 171.17,18.01 169.74,16.57 166.32,16.57 166.24,16.66 163.57,16.66 162.92,17.32 159.85,17.32 159.61,17.55 152.09,17.55 v2(151.66,17.12) 140.5,17.12 138.66,15.28 127.64,15.28 126.5,16.42 119.03,16.42 118.71,16.75 110.81,16.75 108.91,14.85 98.87,14.85 98.06,15.66 90.63,15.66 90.37,15.92 81.89,15.92 81.57,16.24 73.48,16.24 68.17,21.55 v2(68.17,22.61)
  BOTTOM w0.102: 171.38,24.67 171.39,24.65 174.34,24.65 174.35,24.67 174.64,24.67 175.05,25.07 JDIM2.202
  BOTTOM w0.127: JDIM2.202 175.05,27.53 174.96,27.62 174.96,30.97 175.66,31.67 175.66,32.33 176.22,32.89 176.22,36.76 176.22,37.18 175.05,38.35 JDIM1.202 ; 171.38,24.67 171.37,24.68 165.45,24.68 164.58,23.81 163.93,23.81 163.31,23.19 157.63,23.19 v2(156.11,21.67)
SMB_RUN_DAT: length 316.9
  TOP w0.127: v2(152.35,17.09) 152.35,17.37 154.35,19.37 154.35,20.56 155.29,21.49 v2(155.45,21.49) 155.6,21.49 155.88,21.21 156.39,21.21 156.77,21.59 158.18,21.59 158.18,21.59 158.56,21.59 158.9,21.59 158.96,21.53 Q27.1 ; R185.2 179.08,91.75 179.49,91.35 Q12.4 180.35,91.35 v2(180.87,91.87) ; CN8.56 79.06,65.79 79.93,64.92 84.91,64.92 86.46,63.37 86.46,61.77 86.94,61.28 86.94,59.39 86.13,58.57 v1(86.13,57.2) 86.13,55.76 84.9,54.53 84.9,47.38 85.19,47.09 85.82,47.09 86.89,46.03 86.89,38.33 78.92,30.35 74.33,30.35 67.51,23.54 v2(67.51,22.61)
  IN1 w0.14: v2(180.87,91.87) 180.87,89.99 181.13,89.74 181.13,87.3 182.01,86.42 182.01,83.93 183.22,82.72 183.22,78.37 185.6,75.99 185.6,73.43 185.6,73.43 185.6,73.06 185.6,73.06 185.6,67.02 186.49,66.13 186.58,66.04 188.03,66.04 190.44,63.62 190.44,60.54 192.53,58.45 192.53,53.47 192.43,53.37 192.43,53.19 190.76,51.52 190.76,49.81 191.59,48.99 191.59,45.48 188.02,41.91 188.02,35.04 186.47,33.48 186.47,30.83 186.08,30.45 186.08,27.89 183.9,25.71 182.74,24.55 182.74,23.11 180.96,21.33 180.66,21.33 176.95,17.62 173.47,17.62 172.9,17.05 170.77,17.05 169.9,16.18 166.16,16.18 166.07,16.27 163.41,16.27 162.76,16.92 159.69,16.92 159.48,17.13 153.27,17.13 153.24,17.09 v2(152.35,17.09) 152.35,16.94 152.07,16.66 140.6,16.66 138.77,14.83 127.53,14.83 126.34,16.03 118.69,16.03 118.37,16.35 110.97,16.35 109.08,14.45 98.71,14.45 97.89,15.27 90.46,15.27 90.2,15.53 81.73,15.53 81.4,15.85 73.32,15.85 67.51,21.66 v2(67.51,22.61)
  BOTTOM w0.102: JDIM2.200 174.45,25.07 174.25,24.87 171.7,24.87 171.67,24.89 165.15,24.89 164.79,24.54 164.77,24.54
  BOTTOM w0.127: v2(155.45,21.49) 155.45,21.74 157.27,23.57 163.15,23.57 163.77,24.19 164.43,24.19 164.77,24.54 ; JDIM1.200 174.45,38.24 175.72,36.97 175.72,32.94 175.16,32.39 175.16,31.9 174.45,31.2 JDIM2.200
SMBALERT#: length 11.2
  TOP w0.127: R186.1 174.83,89.9 172.2,89.9 v1(171.63,89.33) 171.35,89.05 170.33,89.05 170.07,88.79 170.07,88.28 170.41,87.94 v2(170.41,87.86)
  BOTTOM w0.076: 169.06,87.43 168.93,87.3 168.15,87.3 168.1,87.35 167.69,87.35 167.4,87.05 U25.AN2
  BOTTOM w0.127: 169.06,87.43 169.98,87.43 v2(170.41,87.86)
SMC: length 43.2
  TOP w0.127: BAT14.4 126.25,188.2 v1(126.25,188.14) PR2.1 ; BAT17.10 151.95,184.42 151.41,184.96 151.41,188.32 151.08,188.65 150.56,188.65 v2(150.34,188.86) 150.12,188.65 146.25,188.65 145.95,188.95 145.95,189.84 BAT15.4
  IN1 w0.14: v2(150.34,188.86) 150.14,188.66 149.39,188.66 147.1,186.37 132.85,186.37 131.46,187.77 127.14,187.77 126.91,188 126.91,188.86 BAT14.4
SMD: length 43.4
  TOP w0.127: BAT14.3 124.87,188.82 v1(124.87,188.12) PR1.1 ; BAT17.11 150.95,184.51 151.03,184.58 151.03,188.14 150.9,188.27 150.5,188.27 v2(150.34,188.1) 150.17,188.27 146.07,188.27 145.57,188.77 145.57,189.93 BAT15.3
  IN1 w0.14: v2(150.34,188.1) 150.17,188.27 149.55,188.27 147.27,185.98 132.69,185.98 131.29,187.38 126.95,187.38 126.52,187.81 126.52,188.53 BAT14.3
SMDDR_VREF_DQ0_M3: length 76.7
  TOP w0.508: R350.1 114.1,34.86 C468.1 113.05,36.37 112.29,37.14 112.29,43.88 111.19,44.98 108.66,44.98 108.15,45.49 108.15,63.14 117.66,72.64 132.04,72.64 134.75,75.35 v1(134.75,76.25) 134.75,81.91 136.08,83.24 136.08,85 v2(136.74,85.66)
  BOTTOM w0.254: v2(136.74,85.66) 136.81,85.66 U25.AR51
SMDDR_VREF_DQ1_M3: length 70
  TOP w0.508: v2(136.74,86.33) 136.42,86.33 135.06,84.98 135.06,83.73 133.7,82.37 133.7,81.35 133.35,81 v1(133.35,77.14) 133.35,75.39 131.62,73.66 117.24,73.66 107.14,63.56 107.14,44.99 110.36,41.77 R331.1 109.89,40.09 C440.1
  BOTTOM w0.254: v2(136.74,86.33) 136.82,86.33 137.14,86.65 U25.AP51
SML0ALERT#: length 10.2
  TOP w0.127: v3(170.58,88.54) 171.57,88.54 171.71,88.68 173.26,88.68 173.98,89.4 175.04,89.4 175.49,89.84 R192.2
  BOTTOM w0.076: U25.AL2 167.27,88.55 167.56,88.84 167.99,88.84 168.18,89.04 168.74,89.04 168.95,88.84
  BOTTOM w0.127: v3(170.58,88.54) 170.55,88.57 169.21,88.57 168.95,88.84
SML1ALERT#: length 10.4
  TOP w0.127: v2(166.69,82.34) 166.66,82.37 164.13,82.37 163.35,81.59 163.35,79.65 163.61,79.39 R238.2 163.61,78.02 TP10.1
  BOTTOM w0.076: v2(166.69,82.34) 166.66,82.34 166.32,82.68 166.32,83.36 166.26,83.41 166.26,84.33 165.94,84.66 U25.AU4
SRTC_RST#: length 15.7
  TOP w0.127: v2(168.65,76.67) 168.92,76.4 C358.1 R256.2 167.67,75.62 166.72,74.68 v1(166.72,74.4) 166.77,74.35 R265.1
  IN1 w0.14: v2(168.65,76.67) 168.65,76.94 167.34,78.26 166.6,78.26 165.23,79.63 165.23,82.66 164.15,83.74 v2(164.15,84.51)
  BOTTOM w0.089: v2(164.15,84.51) 164.48,84.19 U25.AV6
SUB_OUT:
  vias: v1(187.98,19.61) v2(187.63,17.88) v2(188.26,17.88)
SUB_OUT14: length 33.2
  TOP w0.635: C8738.1 165.29,4.85 172.25,4.85 v5(172.52,5.11)
  IN1 w0.635: v5(172.52,5.11) 172.75,4.88 177.29,4.88 181.58,9.17 186.64,9.17 188.03,10.57 188.03,16.74 v5(188.38,17.08)
  BOTTOM w0.635: v5(188.38,17.08) 188.47,17 188.47,16.99 188.75,16.7 R609.1
SUB_OUT14_1: length 7.7
  TOP w0.127: C591.1 157.88,5 v1(156.94,5)
  TOP w0.635: R605.1 161.69,6.02 162.19,5.52 R604.1 C592.1 160.94,4.68 160.67,4.41 158.43,4.41 158,4.84 C591.1
SUB_OUT15: length 34.8
  TOP w0.635: v5(194.84,34.92) 194.89,34.92 C460.1
  IN1 w0.635: v5(194.84,34.92) 194.84,34.34 195.73,33.45 197.89,33.45 198.72,34.29 200.28,34.29 201.19,33.37 201.19,29.13 200.18,28.12 197.76,28.12 194.71,25.07 190.02,25.07 188.47,23.52 188.47,23.24 187.16,21.93 185.91,21.93 185.37,21.39 v5(185.37,20.83)
  BOTTOM w0.508: v5(185.37,20.83) 185.7,21.16 v1(186.08,21.16) 186.05,21.13 186.05,20.25 R608.1
SUB_OUT+:
  vias: v1(190.32,131.24)
SUB_OUT+_L: length 8.9
  TOP w0.254: U14.25 186.22,44.64 186.46,44.88 186.6,44.88 EC73.1 187.52,45.49 U14.23
  TOP w0.635: EC73.1 187.36,47.09 C406.1 187.2,47.44 R628.1 v1(187.2,49.96)
SUB_OUT+_L_4P: length 79.9
  TOP w0.635: 128.12,9.55 128.07,9.6 127.99,9.6 127.65,9.94 125.06,9.94 124.71,9.6 117.51,9.6 116.26,8.36 110.15,8.36 108.27,10.24 v1(100.15,10.24) 95.29,10.24 93.97,11.56 86.82,11.56 L40.1
  BOTTOM w0.635: 161.75,10.41 161.18,10.97 161.18,11.93 160.47,12.65 149.32,12.65 145.69,9.02 129.35,9.02 129.2,8.86 v2(128.83,8.86)
  vias: v2(128.19,8.86) v2(162.36,10.21) v2(162.99,10.21)
SUB_OUT+_L_C: length 7.2
  TOP w0.635: CN17.1 80.26,9.63 80.8,10.16 80.8,11.58 81.24,12.02 EC63.1 83.66,12.02 v1(83.8,11.89) L40.2
SUB_OUT+_R_4P_1: length 65.9
  TOP w0.635: 156.1,10.4 149.77,10.4 148.75,11.42 139.49,11.42 134.62,6.55 v1(125.72,6.55) 118.59,6.55 117.47,5.44 108.94,5.44 107.19,7.19 99.49,7.19 97.31,5 96.33,5 v5(96.32,5.01)
  BOTTOM w0.635: L36.1 95.29,6.05 v5(96.32,5.01)
SUB_OUT+_R_4P_15: length 90.8
  TOP w0.635: R628.2 v1(185.72,49.96) 185.72,50.24 v5(185.09,50.88)
  IN2 w0.559: 195.02,77.34 195.46,77.79 195.46,82.89 195.86,83.29 195.86,95.94 194.49,97.31 194.49,101.4
  IN2 w0.584: v5(185.09,50.88) 185.09,51.16 186.79,52.86 186.95,52.86 187.2,53.11 189.15,53.11 191.64,55.6 191.64,59.61 194,61.98 194,63.03 197.99,67.02 197.99,68.71 195.02,71.68 195.02,77.34 ; 193.83,105.13 193.55,104.85 193.55,102.95 194.49,102.01 194.49,101.4
  IN2 w0.635: 197.89,128.58 197.53,128.22 197.53,111.24 196.48,110.19 196.48,107.79 193.83,105.13
  vias: v2(198.42,129.06) v2(198.42,128.42)
SUB_OUT+_R_C: length 12.6
  BOTTOM w0.635: v5(81.28,5.99) 81.53,6.24 v1(85.96,6.24) 92.27,6.24 EC64.1 92.5,6.05 L36.2
SUB_OUT-:
  vias: v1(190.27,124.64)
SUB_OUT-_L: length 9.3
  TOP w0.254: U14.18 190.77,44.64 190.4,45.01 189.88,45.01 189.24,45.64 189.24,44.88 189.47,44.66 U14.20
  TOP w0.635: 189.24,45.64 EC74.1 189.24,46.29 189.12,46.41 C407.1 189.12,48.64 189.03,48.74 R621.1 v1(189.03,50.01)
SUB_OUT-_L_4P: length 78.6
  TOP w0.635: L41.1 86.51,10.67 93.6,10.67 94.92,9.35 v1(102.15,9.35) 107.9,9.35 109.78,7.47 116.63,7.47 117.87,8.71 125.32,8.71
  BOTTOM w0.635: 126.8,9.35 127.35,9.91 127.68,9.91 127.72,9.95 129.37,9.95 129.42,9.91 145.32,9.91 148.96,13.54 161.42,13.54 162.51,12.45
  vias: v2(126.52,8.86) v2(127.15,8.86) v2(162.36,11.63) v2(162.99,11.63)
SUB_OUT-_L_C: length 6.7
  TOP w0.635: L41.2 83.73,10.69 EC68.1 83.62,9.89 v1(82.93,9.19) 82.11,8.38 CN17.2
SUB_OUT-_R_4P_1: length 66.9
  TOP w0.635: 156.6,11.86 154.25,11.86 153.55,11.16 150.1,11.16 149.08,12.18 139.11,12.18 134.36,7.44 v1(127.61,7.44) 118.4,7.44 117.16,6.2 109.26,6.2 107.45,8 98.58,8 v5(96.51,5.93)
  BOTTOM w0.635: v5(96.51,5.93) 96.51,6.18 95.42,7.27 L39.1
SUB_OUT-_R_4P_15: length 84.4
  TOP w0.635: R621.2 190.5,50.09 v1(190.52,50.11) 191.22,50.82 v5(191.35,50.82)
  IN2 w0.559: 196.04,76.66 196.47,77.09 196.47,82.5 196.85,82.88 196.85,96.34 195.55,97.64 195.55,98.02 195.55,98.02 195.55,98.57 195.55,98.57 195.55,102.39 194.59,103.35
  IN2 w0.584: v5(191.35,50.82) 192.38,51.85 192.38,59.34 195.04,62.01 195.04,63.07 199.01,67.03 199.01,69.34 196.04,72.31 196.04,76.66 ; 194.74,104.52 194.59,104.37 194.59,103.35
  IN2 w0.635: 198.45,125.6 198.32,125.48 198.32,110.67 197.24,109.59 197.24,107.02 194.74,104.52
  vias: v2(198.42,127.25) v2(198.42,126.62)
SUB_OUT-_R_C: length 11.9
  BOTTOM w0.635: L39.2 92.58,7.27 EC66.1 92.08,7.39 91.82,7.13 v1(89.16,7.13) v5(81.99,7.13)
SUB_OUT_L+:
  vias: v2(161.85,8.03)
SUB_OUT_LR: length 5.1
  BOTTOM w0.635: v5(165.76,6.66) 165.61,6.81 162.95,6.81 162.66,7.1 v5(160.84,7.1)
SUB_OUT_R+:
  vias: v2(156.56,8.43)
SUB_OUT_RR:
  vias: v1(157.86,6.17)
SUSACK#: length 27.2
  TOP w0.127: v1(178.48,77.09) 178.31,77.09 v2(177.82,76.61)
  IN1 w0.14: v2(174.55,88.87) 174.55,87.07 178,83.62 178,80.67 176.83,79.5 176.83,78.11 177.82,77.11 v2(177.82,76.61)
  BOTTOM w0.076: 170.71,89.23 169.42,89.23 169.05,89.59 167.75,89.59 167.46,89.3 U25.AK2
  BOTTOM w0.127: 170.71,89.23 171.85,89.23 172.41,88.67 173.7,88.67 174.05,88.32 R567.1 175.27,88.43 174.83,88.87 v2(174.55,88.87) ; R7471.2 177.2,75.88 177.82,76.51 v2(177.82,76.61) 177.52,76.91 R7472.2
SUSACK#_EC: length 237.3
  TOP w0.127: v2(50.6,68.94) 50.52,69.01 50.52,71.97 51.08,72.53 U11.82
  IN1 w0.14: v2(177.8,78.77) 178.26,78.77 181.28,75.74 181.28,73.43 182.32,72.39 182.32,66.56 184.2,64.68 184.2,61.76 184.71,61.25 184.71,59.57 184.08,58.94 184.08,48.84 184.37,48.55 184.37,46.75 183.99,46.37 183.99,42.46 184.35,42.1 184.35,37.93 182.49,36.07 182.49,28.04 175.75,21.29 171.19,21.29 170.19,20.29 166.68,20.29 166.34,19.95 165.43,19.95 165.29,19.81 162.74,19.81 162.08,20.47 159.65,20.47 158.98,19.8 133.25,19.8 132.72,19.27 109.95,19.27 109.51,19.27 108.62,18.39 91.8,18.39 91.46,18.05 86.14,18.05 85.34,18.85 83.23,18.85 82.88,19.2 79.32,19.2 78.96,18.85 73.83,18.85 66.77,25.91 65.89,25.91 62.83,28.97 62.83,32.67 62.3,33.19 62.3,33.63 62.3,39.54 62.51,39.74 62.51,42.29 62.23,42.57 62.23,51.62 58.32,55.53 58.32,57.74 54.34,61.72 54.34,63.54 53.47,64.41 53.47,67.11 51.54,69.04 50.7,69.04 v2(50.6,68.94)
  BOTTOM w0.127: R7472.1 177.52,78.48 v2(177.8,78.77) 177.91,78.87 v1(177.91,79.67)
SUSB#: length 242.9
  TOP w0.127: U11.88 50.39,74.93 48.96,73.5 v2(48.96,73.45) ; CN9.2 174.96,68.95 v2(175.04,69.04) 175.97,69.97 178.81,69.97 179.25,70.41 R283.1 ; v2(176.01,64.14) 176.01,63.77 v1(175.66,63.42) 175.44,63.2 174.55,63.2 173.8,62.45 CN9.15
  IN1 w0.14: v2(175.04,69.04) 175.49,68.6 175.49,66.19 175.96,65.72 175.96,64.19 v2(176.01,64.14) ; v2(108.81,25.48) 108.66,25.63 108.66,25.63 106.9,27.38 92.09,27.38 91.69,26.99 87.16,26.99 84.36,29.78 84.36,30.29 77.18,37.48 77.18,43.8 70.5,50.48 70.5,53.18 60.83,62.84 60.83,64.49 58.74,66.59 58.74,69.35 57.68,70.41 56.03,70.41 53.28,73.15 50.54,73.15 49.97,73.73 49.76,73.93 49.41,73.93 48.96,73.49 v2(48.96,73.45)
  IN2 w0.14: v2(176.01,64.14) 176.01,64.01 176.12,63.91 176.12,60.16 175.84,59.88 175.84,58.3 176.8,57.33 176.8,48.06 180.17,44.7 180.17,42.4 179.03,41.26 179.03,35.23 177.07,33.28 177.07,32.3 175.99,31.22 175.99,28.18 176,27.8 173.69,25.49 169.09,25.49 165.99,22.39 153.1,22.39 153.1,22.4 123.67,22.4 123.27,22 119.93,22 119.53,22.4 110.77,22.4 108.81,24.36 v2(108.81,25.48) ; v2(165.5,85.31) 165.86,84.95 165.86,84.3 166.17,84 166.17,80.09 167.59,78.66 167.59,78.44 169.1,76.92 169.1,76.48 168.43,75.81 168.43,74.35 173.51,69.27 174.32,69.27 174.55,69.04 v2(175.04,69.04)
  BOTTOM w0.076: v2(165.5,85.31) 165.7,85.52 U25.AT4
SUSC#: length 267.5
  TOP w0.127: v2(177.27,68.5) 177.72,68.95 177.72,69.32 177.4,69.65 176.4,69.65 v1(175.99,69.24) 175.79,69.04 175.79,68.38 175.36,67.95 174.34,67.95 173.85,67.45 CN9.5 ; U11.18 37.61,71.33 v2(37.9,71.04)
  IN2 w0.14: v2(87.5,16.76) 87.5,17.3 86.61,18.19 86.61,26.95 83.73,29.83 83.31,29.83 82.66,29.83 70.2,42.29 70.2,42.78 65.76,47.23 64.16,47.23 63.54,47.85 63.54,48.39 63.54,48.39 63.54,48.72 53.95,58.31 53.95,58.62 51.68,60.89 51.68,60.89 51.15,61.42 51.15,63.24 47.15,67.25 42.6,67.25 42.19,67.66 41.29,67.66 v2(37.9,71.04) ; v2(164.83,90.13) 164.83,89.7 165,89.53 165,88.82 165.38,88.44 165.76,88.44 166.01,88.19 166.92,88.19 167.36,87.75 167.36,87.12 167.79,86.69 167.79,84.71 169.57,82.93 169.57,78.3 170.41,77.46 170.41,76.3 170.88,75.83 171.66,75.83 171.97,75.53 171.97,74.97 172.5,74.43 172.5,72.43 173.89,71.04 175.54,71.04 176.54,70.04 176.54,69.04 177.07,68.5 v2(177.27,68.5)
  BOTTOM w0.127: v2(164.83,90.13) 164.83,89.86 U25.AJ6 ; v2(177.27,68.5) 176.81,68.04 176.81,66.42 177.84,65.39 177.84,63.24 181.2,59.88 181.2,46.53 182.83,44.9 182.83,26.39 177.33,20.89 174.1,20.89 173.4,20.19 167.67,20.19 166.56,19.09 166.56,18.59 166.29,18.31 165.38,18.31 165.11,18.05 162.44,18.05 161.38,16.98 153.53,16.98 152.73,17.78 146.84,17.78 145.91,16.85 144.22,15.16 126.38,15.16 125.68,15.86 122.01,15.86 118.36,12.22 105.99,12.22 105.34,11.57 95.72,11.57 94.66,12.63 91.78,12.63 88.07,16.35 88.05,16.35 87.63,16.76 v2(87.5,16.76)
SUSON: length 90.8
  TOP w0.127: PR130.1 99.59,33.58 98.7,32.69 98.7,31.32 97.28,29.9 84.42,29.9 v2(82.21,27.69) ; v2(63.3,44.65) 61.49,42.84 v1(61.49,40.44) 61.49,39.17 61.75,38.91 PR118.1 ; U11.35 39.2,64.86 v2(39.58,65.24)
  IN2 w0.14: v2(82.21,27.69) 81.99,27.69 81.43,28.25 81.43,29.01 68.76,41.69 68.76,42 67.34,43.42 67.34,43.42 66.11,44.65 v2(63.3,44.65) 61.17,46.79 61.17,48.54 54.31,55.4 52.83,55.4 48.81,59.41 47.38,60.85 47.15,60.85 46.53,61.47 44.53,61.47 41.22,64.79 40.03,64.79 v2(39.58,65.24)
SUSWARN#: length 26.6
  TOP w0.127: v1(172.27,77.24) 171.5,77.24 v2(171.42,77.32)
  IN2 w0.14: v2(171.42,77.32) 171.42,76.83 172.86,75.39 176.88,75.39 177.5,74.77 177.5,73.27 177.77,73 v2(177.77,72.57)
  BOTTOM w0.076: 168.45,80.44 168.19,80.7 166.81,80.7 165,82.52 165,83.71 165.16,83.88 165.61,83.88 U25.AV4
  BOTTOM w0.127: 168.45,80.44 170.58,78.32 R588.1 170.58,77.9 171.15,77.32 v2(171.42,77.32) 171.8,77.32 172.14,77.66 R7473.2 ; R7471.1 176.42,73.92 v2(177.77,72.57)
SUSWARN#_EC: length 252.4
  TOP w0.127: U11.3 37.56,77.33 37.67,77.44 38.36,77.44 39.81,75.99 39.86,75.99 v2(41.98,73.86)
  IN2 w0.14: v2(41.98,73.86) 43.51,72.34 48.92,72.34 53.69,67.56 53.69,64.54 54.42,63.81 54.42,62.15 56.54,60.04 56.54,58.64 57.99,57.19 61.77,57.19 63.47,55.5 63.47,55.5 67.08,51.88 67.08,50.74 67.38,50.44 67.39,50.44 67.39,50.44 76.22,41.61 76.22,38.92 83.42,31.72 84.24,31.72 84.51,31.72 88.48,27.75 88.48,25.9 89.71,24.67 89.71,16.76 89.29,16.34 88.66,16.34 88.24,16.76 v2(88.24,16.79)
  BOTTOM w0.127: R7473.1 171.98,76.37 171.98,75.16 171.35,74.52 171.02,74.52 170.46,73.97 170.46,70.1 174.64,65.92 174.64,65.39 175.57,64.46 175.57,63.35 176.67,62.26 176.67,61.35 177.72,60.29 178.84,60.29 180.95,58.18 180.95,46.42 182.57,44.8 182.57,26.5 177.22,21.15 173.99,21.15 173.29,20.45 167.56,20.45 166.33,19.22 165.93,19.22 165.37,18.66 165.37,18.66 165.01,18.3 162.34,18.3 161.27,17.23 153.63,17.23 152.83,18.03 146.74,18.03 145.81,17.11 144.12,15.42 126.49,15.42 125.79,16.12 121.9,16.12 118.46,12.67 104.21,12.67 103.36,11.82 95.83,11.82 94.77,12.89 91.92,12.89 88.24,16.57 v2(88.24,16.79)
SWN: length 35.4
  TOP w0.127: v2(87.29,86.67) 87.29,87.41 v1(87.27,87.43)
  TOP w0.254: PR80.2 87.29,86.02 v2(87.29,86.67)
  IN1 w0.254: v2(110.36,105.84) 110.36,103.66 109.98,103.28 102.87,103.28 100.8,101.21 100.16,101.21 87.29,88.33 v2(87.29,86.67)
  BOTTOM w0.254: v2(110.36,105.84) PR158.1
SY8208BBST: length 7.3
  BOTTOM w0.635: 54.25,52.76 v1(54.76,53.26) 54.85,53.35 58.07,53.35 58.38,53.04 58.38,50.91 58.19,50.72 PR178.2
SY8208BBST_S: length 2.3
  BOTTOM w0.635: PC213.1 57.43,47.19 58.09,47.85 v1(58.34,47.85) 58.34,48.69 PR178.1
SY8208BEN: length 5.2
  TOP w0.127: v2(55.52,48.65) 55.91,48.26 PR112.2
  BOTTOM w0.127: PU11.1 56,49.47 PR179.1 PC209.2 55.86,48.31 v2(55.52,48.65)
SY8208BFB: length 1.8
  BOTTOM w0.127: PR177.1 56.12,50.37 PU11.3
SY8208BLDOEN: length 6.6
  BOTTOM w0.127: v1(53.74,55.3) 53.87,55.42 PR173.1 54.88,55.3 55.66,54.52 PR174.1 55.66,54.28 55.35,53.97 54.57,53.97 53.66,53.06 PU11.7
SY8208BPG: length 2.7
  TOP w0.127: PR110.1 56.49,49.92 v2(55.04,49.92)
  BOTTOM w0.127: PU11.2 v2(55.04,49.92)
SY8208BSW:
  vias: v1(48.16,47.8)
SY8208BVOUT: length 17.8
  IN1 w0.14: v2(58.39,39.04) 58.44,39.08 58.44,48.69 55.97,51.16 v2(55.52,51.16)
  BOTTOM w0.127: v2(58.39,39.04) 58.53,39.18 58.84,39.18 59.05,39.39 PR188.1 ; PU11.4 54.82,50.82 55.01,50.63 55.68,50.63 56.15,51.1 PC204.1 55.73,51.36 v2(55.52,51.16)
SY8208CBST: length 15.3
  IN2 w0.635: v2(32.79,50.72) 33.55,51.49 37.49,51.49 37.87,51.11 37.87,50.52 38.43,49.96 42.47,49.96 v2(43.91,48.51)
  BOTTOM w0.254: v2(43.91,48.51) 43.76,48.36 PU12.6
  BOTTOM w0.635: v2(32.79,50.72) 32,51.51 PR175.2
SY8208CBST_S: length 1.8
  BOTTOM w0.508: PC200.1 32.55,52.98 PR175.1
SY8208CEN: length 32.2
  TOP w0.127: v2(40.18,48.36) 40.79,48.97 44.09,48.97 44.4,48.66 53.8,48.66 53.86,48.72 53.9,48.72 54.58,49.4 54.58,52.17 54.86,52.45 v1(56.36,52.45) 56.86,52.95 56.86,53.53 57.35,54.03 57.35,55.96 57.86,56.46 PQ40.3
  BOTTOM w0.127: PR185.1 PR184.1 PR183.1 PC211.2 40.81,47.18 PU12.1 v2(40.18,48.36)
SY8208CFB: length 2.1
  BOTTOM w0.127: PU12.3 41.71,48.02 42.8,46.93 PR182.1
SY8208CVOUT: length 6.9
  BOTTOM w0.127: PU12.4 42.16,47.93 42.54,47.55 43.39,47.55 PC214.1 44.49,46.46 44.49,44.02 v2(44.19,43.73) 44.18,43.74 PR187.1
SYS_I: length 182
  TOP w0.127: v2(83.59,178.49) 83.69,178.39 85.84,178.39 PR12.1 ; U11.68 53.78,66.93 PC68.1 56.21,65.39 59.77,65.39 v1(60.35,65.96) 60.71,66.32 v2(60.71,68.04)
  IN1 w0.14: v2(81.41,166.68) 80.82,167.26 80.82,170 79.47,171.35 79.47,175.11 82.85,178.49 v2(83.59,178.49)
  BOTTOM w0.127: v2(81.41,166.68) 80.59,165.86 80.59,160.84 76.42,156.67 50.36,156.67 34.31,140.62 34.31,116.56 36.63,114.25 36.63,111.79 37.03,111.38 37.03,110.11 45.55,101.59 45.55,97.78 48.99,94.33 48.99,88.39 56.02,81.36 56.02,81.07 56.43,80.66 56.73,80.66 62.05,75.33 62.05,71.72 64.72,69.06 64.72,66.29 64.36,65.94 63.83,65.94 61.73,68.04 v2(60.71,68.04)
SYS_RESET#: length 51.5
  TOP w0.127: CN9.13 174.97,63.45 175.14,63.62 175.14,63.9 176.04,64.8 v2(177.39,64.8)
  BOTTOM w0.127: v2(177.39,64.8) 177.39,65.48 176.33,66.55 176.33,67.6 176.3,67.63 176.3,70.46 178.22,72.38 178.22,72.75 177.96,73.01 177.69,73.01 177.47,73.23 177.47,74.27 177.82,74.63 177.82,75.79 178.29,76.26 178.29,79.07 178.48,79.26 178.48,82.67 v2(178.5,82.69) 178.8,82.98 180.57,82.98 181.44,83.85 181.44,87.44 180.94,87.94 180.28,87.94 180.02,88.2 180.02,89.93 178.9,91.05 178.9,91.76 177.9,92.75 R551.1 177.13,92.75 176.7,92.32 174.65,92.32 174.02,91.69 171.8,91.69 171.32,92.18 169.77,92.18 169.37,92.58 168.08,92.58 168.05,92.62 167.01,92.62 U25.AC3
TD_IREF: length 10
  BOTTOM w0.127: U25.B12 160.44,105.02 160.2,105.27 160.2,106.77 160.51,107.08 160.51,108.92 160.5,108.93 160.5,112.93 v1(160.78,113.21) 161.19,113.61 R484.1
TEMP_MBAT: length 165.8
  TOP w0.127: v2(103.12,119.69) 97.31,113.87 97.31,110.76 79.45,92.9 65.13,92.9 64.9,92.66 64.9,87.29 66.2,85.98 66.2,82 64.69,80.49 v1(64.69,79.3) 64.01,78.61 64.01,77.09 58.83,71.92 PC67.2 58.39,66.54 55.08,66.54 53.89,67.73 U11.70 ; PR3.2 v2(127.66,185.84)
  IN1 w0.14: v2(103.22,132.72) 102.72,133.22 102.72,160.91 v2(127.66,185.84)
  IN2 w0.14: v2(103.12,119.69) 103.22,119.79 v2(103.22,132.72)
TEST_A4: length 10.5
  BOTTOM w0.127: U25.A4 166.93,106.42 166.93,108.77 169.95,111.79 TP21.1
TEST_A60: length 12.4
  BOTTOM w0.127: TP26.1 120.22,104.9 120.72,104.9 120.83,104.8 122.27,104.8 122.71,105.23 128.04,105.23 129.03,106.22 130.23,106.22 130.34,106.11 130.74,106.11 131.19,105.66 U25.A60
TEST_A62: length 10.7
  BOTTOM w0.127: U25.A62 129.28,105.51 128.49,104.72 126.24,104.72 125.3,103.78 120.06,103.78 TP27.1
TEST_AV1: length 14.6
  BOTTOM w0.127: U25.AV1 168.1,84.01 169.91,84.01 170.5,84.59 170.5,85.07 171.52,86.1 176.61,86.1 176.75,85.95 177.24,85.95 178.8,84.39 179.84,84.39 TP33.1
TEST_AW1: length 13.2
  BOTTOM w0.127: TP32.1 178.83,84.14 178.7,84.14 177.13,85.7 176.64,85.7 176.5,85.84 171.73,85.84 170.87,84.98 170.87,84.61 169.72,83.46 167.92,83.46 U25.AW1
TEST_AW63: length 7.6
  BOTTOM w0.127: TP34.1 125.25,78.48 129.29,82.52 U25.AW63
TEST_AY60: length 10.2
  BOTTOM w0.127: U25.AY60 130.05,81.77 130.05,79.32 128.25,77.52 126.77,77.52 TP36.1
TEST_B2: length 10.9
  BOTTOM w0.127: U25.B2 167.41,108.79 171.22,112.61 TP22.1
THRM_ALERT_HW#1: length 30.7
  TOP w0.127: Q16.1 32.03,83.5 32.69,84.16 32.69,85.12 32.93,85.36 R207.1 33.92,85.36 34.06,85.22 v1(34.06,84.25) 34.06,84.14 34.76,83.44 34.76,82.31 38.47,78.59 39.18,78.59 40.88,76.89 40.88,76.65 v2(40.99,76.55) ; v2(51.26,71.98) 51.51,71.73 U11.80
  IN2 w0.14: v2(51.26,71.98) 51.26,73.79 49.42,75.62 41.91,75.62 v2(40.99,76.55)
THRM_MOINTOR1: length 70.9
  TOP w0.127: U11.72 54.51,68.53 v2(54.76,68.78) 54.91,68.63 C376.2 ; R280.1 C375.2 R162.2 25.68,102.29 v1(26.44,103.05) 26.82,103.43 26.82,108.51 27.71,109.4 28.09,109.4 v2(28.47,109.78)
  BOTTOM w0.127: v2(54.76,68.78) 54.62,68.78 52.04,71.36 52.04,75.82 44.98,82.88 44.98,83.64 40,88.62 40,90.5 39.37,91.14 39.37,93.95 40.28,94.87 40.28,97.08 39.91,97.45 39.91,103.7 33.83,109.78 v2(28.47,109.78)
TP_SMB_CLK: length 20.7
  TOP w0.127: CN16.2 175.25,20.4 174.17,21.49 171,21.49 171,21.49 170.58,21.49 169.54,20.45 169.54,18.24 169.11,17.82 v2(166.8,17.82) 166.38,17.82 165.36,18.84 R403.1 164.23,18.84 163.47,19.6 C565.2 162.81,19.62 162.58,19.85 160.87,19.85 160.49,20.23 Q27.3
TP_SMB_DATA: length 20.9
  TOP w0.127: Q27.6 162.64,21.53 162.76,21.65 C561.2 R401.1 165.54,21.65 166.5,20.7 166.5,19.63 v2(166.48,19.62) 166.48,19.4 166.65,19.23 166.65,18.62 166.98,18.29 169.1,18.29 169.28,18.47 169.28,20.55 169.57,20.84 169.57,20.87 170.44,21.74 171.07,21.74 174.27,21.74 176.25,19.76 CN16.1
TPCLK: length 162.4
  TOP w0.127: v2(50.31,65.54) 50.18,65.67 50.18,65.74 50.01,65.91 50.01,72.24 51.51,73.73 U11.85 ; L38.1 159.53,18.21 R415.2 155.62,18.33 153.69,16.41 131.62,16.41 131.03,15.81 127.32,15.81 123.75,12.24 111.21,12.24 110.63,12.83 108.84,12.83 108.84,12.83 108,12.83 108,12.83 96.67,12.83 94.69,14.81 v1(90.04,14.81) 81.5,14.81 v2(80.48,13.78)
  IN1 w0.14: v2(50.31,65.54) 50.31,65.44 50.74,65 50.74,61.46 55.35,56.85 55.35,54.96 59.48,50.83 59.48,28.67 59.59,28.56 59.59,27.53 72.72,14.4 79.86,14.4 v2(80.48,13.78)
TPCLK-1: length 16.5
  TOP w0.127: L38.2 161.44,18.33 C575.1 165.15,18.33 166.17,17.31 168.22,17.31 ; 168.22,17.31 v2(168.22,17.3) ; 168.22,17.31 169.32,17.31 170.04,18.03 170.04,20.24 170.79,20.98 172.77,20.98 173.25,20.5 CN16.4
TPDATA: length 164.6
  TOP w0.127: v2(49.67,65.53) 49.5,65.7 49.5,72.45 51.19,74.13 U11.86 ; L35.1 159.53,17.2 R412.2 158.7,17.79 155.79,17.79 153.9,15.9 131.83,15.9 131.24,15.31 127.53,15.31 123.96,11.74 111,11.74 110.42,12.32 109.05,12.32 109.05,12.32 107.79,12.32 107.79,12.32 96.46,12.32 94.49,14.29 86.27,14.29 v1(85.39,13.41) 85.24,13.56 81.53,13.56 81.15,13.18 80.34,13.18 v2(79.74,13.78)
  IN1 w0.14: v2(49.67,65.53) 49.67,65.34 50.22,64.79 50.22,61.24 54.83,56.64 54.83,54.66 58.47,51.02 58.47,49.41 58.96,48.92 58.96,28.45 59.07,28.34 59.07,27.32 72.5,13.88 79.64,13.88 v2(79.74,13.78)
TPDATA-1: length 15.7
  TOP w0.127: CN16.5 172.25,20.31 172.08,20.47 171,20.47 170.55,20.03 170.55,17.82 169.8,17.07 v2(169.8,17.04) 169.77,17.04 169.53,16.8 165.96,16.8 164.94,17.82 163.2,17.82 C572.1 162.08,17.45 161.58,17.45 L35.2
TPM_PP: length 4.1
  TOP w0.127: U18.7 75.15,21.2 R385.2 R392.1 75.09,20.13 74.95,19.99 v2(74.95,19.61)
TPM_TESTB1: length 8.2
  TOP w0.127: R365.1 79.54,25.8 79.14,25.4 v2(79.14,21.79) 79.14,20.39 78.66,19.9 U18.9
TRA_V_DAC: length 39.7
  TOP w0.508: U6.10 28.22,155.88 28.23,155.87 28.75,155.87 ; U7.15 28.72,141.27 ; 28.72,141.27 29.23,141.78 29.23,146.36 v1(27.38,148.21) 27.24,148.35 C115.1 29.17,153.12 29.17,155.45 28.75,155.87 ; 28.72,141.27 29.35,140.64 29.35,135.42 28.85,134.93 26.59,134.93 U7.10 ; 28.75,155.87 30.12,157.24 30.12,161.09 28.98,162.23 U6.15
TS_INTB#: length 4
  TOP w0.127: CN2.15 65.85,176.62 v1(65.53,176.3) EC3.2 R19.2
TS_INTB#_1: length 7
  BOTTOM w0.076: 169.16,97.09 166.94,97.09 166.83,97.19 166.44,97.19 166.12,97.51 U25.P4
  BOTTOM w0.127: R523.1 172.21,98.22 171.72,97.73 v1(171.29,97.73) 170.92,97.73 170.27,97.09 169.16,97.09
TS_ON: length 175.2
  TOP w0.127: v2(46.51,175.57) 48.86,173.22 48.86,169.54 49.63,168.77 v2(49.63,168.45) ; U11.29 35.87,66.93 35.24,66.29 v2(34.65,66.29) ; v2(29.36,169.22) 32.41,169.22 38.38,175.18 v1(38.63,175.18) 40.03,175.18 v2(40.41,175.57) ; v2(63.85,174.07) 64.02,174.23 R19.1
  IN1 w0.14: v2(46.51,175.57) v2(40.41,175.57)
  BOTTOM w0.127: v2(49.63,168.45) 57.15,168.45 60.81,172.11 63.73,172.11 64.16,172.54 64.16,173.76 v2(63.85,174.07) ; v2(29.36,169.22) 29.81,168.77 29.81,153.4 29.03,152.63 29.03,126.16 24.84,121.97 24.16,121.97 22.5,120.31 16.75,120.31 16.15,119.72 16.15,118.75 16.66,118.24 17.52,118.24 19.25,116.51 19.25,115.01 20.37,113.89 20.37,108.86 20.81,108.42 20.81,105.61 24.66,101.76 24.66,97.84 25.04,97.46 26.34,97.46 30.52,93.28 30.52,79.92 29.48,78.89 29.48,74.56 31.65,72.39 31.65,70.9 34.65,67.9 v2(34.65,66.29) ; v2(40.41,175.57) Q7030.2
TSENSE: length 4
  TOP w0.203: v2(92.15,86.91) 92.48,86.91 92.82,86.58 PU3.13
  TOP w0.254: PR73.1 92.11,86.96 v2(92.15,86.91)
  BOTTOM w0.381: PC173.1 92.92,86.55 v1(92.91,86.54) 92.9,86.55 92.52,86.55 v2(92.15,86.91)
TST: length 5.3
  TOP w0.127: U15.14 192.48,28.13 192.56,28.05 194.77,28.05 195.16,27.66 195.16,27.28 R364.1 v2(194.64,26.85)
TST2: length 2.8
  TOP w0.127: U8021.14 60.26,168.57 v1(59.89,168.94) 59.61,169.22 59.46,169.22 59.36,169.31 59.36,169.32 R8517.1
UART0_CTS: length 10.8
  BOTTOM w0.127: RP5.3 176.43,104.19 176.11,104.51 173.82,104.51 173.61,104.72 172.62,104.72 v1(172.08,104.19) 171.58,104.19 168.68,101.29 U25.G1
UART0_RTS: length 10.7
  BOTTOM w0.076: 168.87,101.1 168.77,101 167.72,101 U25.J2
  BOTTOM w0.127: RP5.2 175.79,104.11 175.65,104.25 173.42,104.25 v1(173.35,104.19) 172.82,103.66 171.43,103.66 168.87,101.1
UART0_RXD: length 10.3
  BOTTOM w0.089: 169.15,100.65 169.06,100.57 167.94,100.57 U25.J1
  BOTTOM w0.127: 169.15,100.65 171.36,102.87 172.3,102.87 v1(172.31,102.88) 172.32,102.87 173.53,102.87 174.17,102.23 174.17,101.82 174.93,101.07 175.37,101.07 175.79,101.48 RP5.9
UART0_TXD: length 17.8
  TOP w0.127: v2(180.77,100.86) 179.12,102.51 170.05,102.51 168.17,100.64 167.69,100.64 166.91,99.85 v3(166.91,99.42)
  BOTTOM w0.114: U25.K3 166.91,99.53 v3(166.91,99.42)
  BOTTOM w0.127: v2(180.77,100.86) 181.38,101.47 RP6.6
UART1_CTS: length 12.8
  BOTTOM w0.076: U25.J4 166.31,100.16 166.7,100.16 166.78,100.08 167.51,100.08 167.67,100.25 168.03,100.25 168.18,100.39
  BOTTOM w0.089: 168.18,100.39 169.24,100.39
  BOTTOM w0.127: RP5.8 176.43,101.48 175.75,100.81 174.82,100.81 173.92,101.72 173.92,101.73 v2(173.73,101.92) 173.3,102.35 171.2,102.35 169.24,100.39
UART1_RST: length 11.1
  BOTTOM w0.076: U25.J3 166.87,100.25 167.38,100.25 167.6,100.46 167.6,100.64 167.79,100.83 168.97,100.83
  BOTTOM w0.127: RP5.1 175.16,102.92 174.9,102.67 174.65,102.67 v1(174.14,103.18) 173.91,103.4 171.54,103.4 168.97,100.83
UART1_RXD: length 20
  TOP w0.127: RP2.9 182.45,105.85 181.99,105.4 181.77,105.4 180.03,103.66 175.51,103.66 v1(175.03,103.18) 174.62,102.77 169.92,102.77 168.04,100.89 167.54,100.89 166.28,99.63 v2(166.28,99.42)
  BOTTOM w0.089: v2(166.28,99.42) 166.28,99.47 165.96,99.78 U25.K4
UART1_TXD: length 12.5
  BOTTOM w0.076: 168.32,101.58 167.56,101.58 U25.G2
  BOTTOM w0.127: RP5.4 177.06,104.01 176.31,104.76 173.95,104.76 173.4,105.31 v1(172.72,105.31) 172.34,105.31 168.58,101.55 168.36,101.55 168.32,101.58
ULT_EDP_HPD: length 164.8
  TOP w0.127: CN2.25 v2(60.85,176.38)
  IN1 w0.14: v2(159.51,123.2) 159.37,123.2 158.87,122.7 157.93,122.7 157.42,123.21 138.65,123.21 135.68,126.18 135.24,126.18 135.24,126.18 132.7,126.18 131.46,127.43 129.99,127.43 128.56,126 128.56,124.28 126.88,122.6 122.71,122.6 121.01,124.3 121.01,128.26 117.83,131.43 102.86,131.43 101.85,132.45 101.85,139.63 79.78,161.7 79.78,169.57 72.7,176.65 61.12,176.65 v2(60.85,176.38)
  BOTTOM w0.076: 165.03,105.94 165.03,105.04 165.1,104.96 165.1,104.72 164.54,104.17 U25.D6
  BOTTOM w0.127: v2(159.51,123.2) 159.62,123.09 160.77,123.09 v1(161.01,122.86) 161.31,122.56 164.92,122.56 165.23,122.25 165.23,121.54 166.03,120.74 166.03,120.1 165.63,119.71 165.63,115.99 165.88,115.75 R483.1 R487.1 165.68,114.03 165.68,106.6 165.03,105.94
USB3_1+: length 2
  TOP w0.127: R305.2 22.16,58.32 23.06,58.32 23.27,58.52 C389.2
USB3_1-: length 1.9
  TOP w0.127: R306.2 22.13,58.09 23.09,58.09 23.26,57.92 C391.2
USB3_2+: length 2.2
  TOP w0.127: C417.2 21.6,47.08 21.46,46.94 20.79,46.94 20.33,47.4 R322.2
USB3_2-: length 2.3
  TOP w0.127: R324.2 20.3,46.25 20.75,46.71 21.36,46.71 21.6,46.47 C420.2
USB3_SSRX+: length 8.1
  TOP w0.127: CN2.6 70.35,177.35 70.48,177.22 70.48,177.04 v1(69.95,176.5) 70.48,175.97 70.48,172.75 69.95,172.22 C8775.2 70.48,171.67 70.48,171.46 R8551.1
USB3_SSRX+_DC: length 11
  TOP w0.127: v2(63.31,170.92) 63.55,170.68 63.55,170.38 63.39,170.23 U8021.9 ; C8775.1 v2(69.95,173.61)
  IN1 w0.14: v2(69.95,173.61) 70.47,173.09 70.47,172.88 69.71,172.12 64.2,172.12 63.59,171.51 63.59,171.2 v2(63.31,170.92)
USB3_SSRX-: length 8
  TOP w0.127: CN2.5 70.85,177.35 70.71,177.22 70.71,177.01 v1(71.22,176.5) 70.71,176 70.71,172.71 C8774.2 70.71,171.69 70.71,171.44 R8550.1
USB3_SSRX-_DC: length 11
  TOP w0.127: U8021.8 63.89,170.24 63.78,170.36 63.78,170.63 v2(64.07,170.92) ; C8774.1 v2(71.22,173.61)
  IN1 w0.14: v2(64.07,170.92) 63.85,171.14 63.85,171.4 64.31,171.86 69.82,171.86 70.74,172.77 70.74,173.13 v2(71.22,173.61)
USB3_SSTX+: length 8.4
  TOP w0.127: CN2.3 71.85,177.14 71.93,177.06 71.93,175.69 v1(71.47,175.23) 71.9,174.81 71.96,174.81 72.07,174.7 72.07,174.7 73,173.77 73,172.71 C8745.2 73.02,171.67 73.02,171.46 R8553.1
USB3_SSTX+_DC: length 17.3
  TOP w0.127: U8021.12 61.89,170.23 62.05,170.38 62.05,170.66 v2(61.78,170.92) ; C8745.1 v2(72.49,173.61)
  IN1 w0.14: v2(72.49,173.61) 73.01,173.09 73.01,172.98 72.84,172.81 72.35,172.81 71.96,173.2 71.96,174.02 71.09,174.88 68.91,174.88 67.2,173.16 63.59,173.16 62.09,171.66 62.09,171.23 v2(61.78,170.92)
USB3_SSTX-: length 8.5
  TOP w0.127: CN2.2 72.35,177.28 72.16,177.09 72.16,175.82 v1(72.74,175.23) 72.67,175.23 72.31,174.88 72.31,174.78 73.23,173.86 73.23,172.73 C8786.2 73.25,171.69 73.25,171.44 R8552.1
USB3_SSTX-_DC: length 17.2
  TOP w0.127: U8021.11 62.39,170.27 62.28,170.38 62.28,170.66 v2(62.55,170.92) ; C8786.1 v2(73.76,173.61)
  IN1 w0.14: v2(73.76,173.61) 73.28,173.13 73.28,172.87 72.95,172.54 72.24,172.54 71.69,173.09 71.69,173.91 70.98,174.61 69.02,174.61 67.31,172.9 63.7,172.9 62.36,171.55 62.36,171.11 v2(62.55,170.92)
USB30_RX1+: length 181.6
  TOP w0.127: R312.2 22.08,53.82 23.59,53.82 24.77,55 25.07,55 v1(25.63,55.55) 26.13,55.04 26.39,55.04 31.32,59.97 31.32,72.08 28.04,75.35 28.04,80.11 v2(27.78,80.37)
  IN1 w0.14: v2(27.78,80.37) 28.01,80.14 28.01,79.76 28.3,79.47 35.04,79.47 36.41,78.1 63.54,78.1 65.43,76.2 74.86,76.2 75.48,76.83 80.98,76.83 81.35,76.45 89.48,76.45 89.83,76.8 97.04,76.8 97.2,76.64 102.56,76.64 108.58,82.67 108.58,87.74 110.79,89.94 110.94,89.94 114.12,93.12 114.12,93.26 118.82,97.96 121.77,97.96 122.14,98.32 122.88,98.32 125.98,101.42 131.44,101.42 131.94,100.93 134.2,100.93 136.26,98.87 148.6,98.87 149.67,99.94 152.59,99.94 153.3,100.65 154.15,100.65 154.66,101.16 155.92,101.16 v2(156.08,101)
  BOTTOM w0.127: v2(156.08,101) 156.24,101.16 156.52,101.16 U25.H20
USB30_RX1+_C: length 11.7
  TOP w0.127: R312.1 20.56,53.75 19.71,53.75 v1(19.21,54.24) 18.69,53.72 18.46,53.72 16.81,55.37 16.81,57.5 15.97,58.34 15.14,58.34 14.6,57.81 14.25,57.81 13.9,58.16 CN25.6
USB30_RX1+_DC: length 11.6
  TOP w0.127: U8021.22 63.39,165.3 63.53,165.16 63.53,164.94 64.19,164.27 68.29,164.27 68.42,164.14 v1(68.42,163.5) 68.44,163.48 69.17,163.48 69.35,163.3 70.09,163.3 v2(70.36,163.03)
  BOTTOM w0.127: C8782.2 72.28,163.3 70.62,163.3 v2(70.36,163.03)
USB30_RX1+_L: length 9.2
  TOP w0.127: R8551.2 70.47,169.63 70.47,166.21 v1(69.95,165.68) 70.47,165.16 70.47,164.72 71.89,163.3 72.28,163.3 R8547.1
USB30_RX1-: length 181.6
  TOP w0.127: R314.2 22.21,53.59 23.69,53.59 24.86,54.77 25.14,54.77 v1(25.63,54.28) 26.16,54.81 26.48,54.81 31.54,59.88 31.54,72.17 28.27,75.45 28.27,80.11 v2(28.55,80.39)
  IN1 w0.14: v2(156.15,101.67) 155.9,101.42 154.55,101.42 154.04,100.91 153.19,100.91 152.48,100.2 149.56,100.2 148.49,99.14 136.37,99.14 134.31,101.2 132.05,101.2 131.55,101.69 125.87,101.69 122.77,98.59 122.03,98.59 121.66,98.22 118.71,98.22 113.85,93.37 113.85,93.23 110.83,90.21 110.68,90.21 108.32,87.85 108.32,82.78 102.45,76.91 97.31,76.91 97.15,77.06 89.71,77.06 89.37,76.72 81.46,76.72 81.09,77.1 75.37,77.1 74.75,76.47 65.54,76.47 63.65,78.37 36.52,78.37 35.15,79.74 28.41,79.74 28.28,79.87 28.28,80.12 v2(28.55,80.39)
  BOTTOM w0.127: U25.G20 156.72,101.57 156.25,101.57 v2(156.15,101.67)
USB30_RX1-_C: length 11.7
  TOP w0.127: CN25.5 13.9,57.23 14.25,57.58 14.7,57.58 15.23,58.12 15.87,58.12 16.58,57.4 16.58,55.27 18.36,53.49 18.69,53.49 v1(19.21,52.97) 19.76,53.52 20.59,53.52 R314.1
USB30_RX1-_DC: length 11.7
  TOP w0.127: v2(70.36,163.79) 70.36,163.6 70.28,163.53 69.44,163.53 69.33,163.64 69.33,164.39 v1(69.32,164.4) 68.49,164.4 68.38,164.5 64.29,164.5 63.76,165.03 63.76,165.16 63.89,165.3 U8021.23
  BOTTOM w0.127: C8746.2 72.76,163.62 72.67,163.53 70.62,163.53 v2(70.36,163.79)
USB30_RX1-_L: length 9.1
  TOP w0.127: R8546.1 72.76,163.85 72.44,163.53 71.99,163.53 70.7,164.81 70.7,165.16 v1(71.22,165.68) 70.7,166.21 70.7,170.09 70.76,170.15 R8550.2
