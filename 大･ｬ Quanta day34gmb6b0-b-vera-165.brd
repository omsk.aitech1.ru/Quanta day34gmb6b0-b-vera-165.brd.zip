# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17271649:
  vias: v1(92.62,14.8)
N17271663: length 1.3
  BOTTOM w0.305: 93.24,33.33 93.37,33.2 CN29.74
  vias: v1(92.73,32.41)
N17271713: length 4
  TOP w0.127: v2(96.8,16.23) 96.85,16.18 TP13.1
  BOTTOM w0.127: CN29.10 95.9,17.2 96.8,16.31 v2(96.8,16.23)
N17271729: length 3
  TOP w0.127: v2(92.61,24.2) 92.48,24.33 R601.2
  BOTTOM w0.127: v2(92.61,24.2) CN29.38
N17276146: length 3
  TOP w0.127: v1(84.22,51.61) 84.22,50.93 v2(84.1,50.81) R318.2
  BOTTOM w0.127: v2(84.1,50.81) 84.05,50.76 CN26.44
N17345620: length 1.8
  TOP w0.127: U15.7 188.77,26.32 189,26.09 189,25.71 189.13,25.58 R369.1
N17351782: length 1.4
  BOTTOM w0.254: C803.1 191.92,16.56 192.06,16.7 U28.17
N17351786: length 4.6
  BOTTOM w0.254: U28.15 193.59,14.93 193.44,14.78 192.81,14.78 192.05,15.55 C804.2 191.88,16.13 192.25,16.13 192.32,16.2 U28.16
N17351800: length 1.4
  BOTTOM w0.254: C799.1 194.97,20.08 195.09,19.96 U28.4
N17351802: length 3.1
  BOTTOM w0.254: U28.2 194.09,19.6 193.8,19.89 192.4,19.89 C798.1
N17351825: length 2.4
  BOTTOM w0.254: U28.18 192.05,17.2 191.89,17.04 190.99,17.04 C803.2
N17351895: length 4.7
  TOP w0.127: C434.2 195.58,41.4 196.26,42.09 v2(196.26,42.24)
  TOP w0.254: R337.2 195.58,39.07 C439.1 195.58,39.77 C434.2
N17351898: length 19.3
  TOP w0.254: U14.17 191.42,46.84 C407.2 190.91,47.94 191.46,48.49 191.46,50.12 191.92,50.58 191.92,51.05 191.52,51.45 v1(190.03,51.45) 188.81,51.45 188.36,51 188.36,49.28 188.36,49.27 188.36,45.39 188.82,44.94 U14.21
N17351904: length 20.2
  TOP w0.254: U14.26 185.57,44.58 185.29,44.86 185.06,44.86 184.53,45.39 184.53,46.56 C406.2 185.31,47.86 184.22,48.95 v1(184.22,50.14) 184.22,51.13 184.54,51.45 187.72,51.45 187.98,51.19 187.98,44.77 188.17,44.58 U14.22
N17351907: length 3.8
  TOP w0.127: v2(196.59,44.79) 195.94,44.79 R326.2
  TOP w0.254: R326.2 R328.2 195.58,42.31 C428.1
N17351912: length 3.4
  TOP w0.254: R347.2 192.32,36.22 v2(193.2,36.22) 193.45,36.22 R341.1 194.11,36.88 R337.1
N17351914: length 8.1
  TOP w0.127: v1(185.6,32.23) 186.18,32.82 186.18,33.61 R354.1
  TOP w0.254: U14.6 187.52,37.3 186.94,36.73 186.3,36.73 R346.2 185.97,36.13 186.21,35.89 186.21,34.6 R354.1
N17351950: length 6
  TOP w0.254: C428.2 193.83,41.96 192.2,40.34 192.2,39.89 191.73,39.42 191.16,39.42 190.77,39.03 U14.11
N17351952: length 5.9
  TOP w0.254: C439.2 193.65,39.42 193.32,39.09 193.32,37.39 193.04,37.11 191.62,37.11 191.42,37.31 U14.12
N17351965: length 7.4
  TOP w0.127: R353.1 184.34,34.07 184.25,34.16 183.69,34.16 v2(183.51,33.99)
  TOP w0.254: U14.5 186.87,37.32 186.66,37.11 185.66,37.11 R345.2 184.42,36.1 184.17,35.85 184.17,34.72 184.68,34.21 R353.1
N17351980: length 7
  TOP w0.127: R355.1 186.87,33.1 v2(187.42,32.54)
  TOP w0.254: U14.9 189.47,37.31 189.31,37.16 189.3,37.16 189,36.86 189,35.55 188.98,35.53 188.98,35.36 C467.2 187.07,33.45 R355.1
N17351981: length 5.6
  TOP w0.254: U14.10 190.12,36.7 R343.1 189.66,35.09 C464.2 189.23,34.66 189.23,34.15 v2(189.24,34.14) 189.1,34.14 188.42,33.45 R355.2
N17352017: length 3.2
  TOP w0.127: C460.2 194.11,34.8 v2(193.98,34.67)
  TOP w0.254: R347.1 193.09,35.61 C460.2
N17352037: length 1.4
  TOP w0.254: C590.1 R423.1
N17352048: length 2.2
  TOP w0.305: R426.1 163.45,6.27 v2(163.27,6.45) 163.24,6.48 163.24,6.87 C593.1
N17352052: length 4
  TOP w0.127: U21.1 163.36,9.72 v2(163.42,9.65) 163.56,9.79 164.21,9.79 R419.2 R418.2
N17352055: length 6.2
  TOP w0.254: U21.15 157.54,9.7 v2(156.49,9.7) R416.2 ; R417.2 v2(153.52,9.7)
  IN1 w0.381: v2(156.49,9.7) 156.01,9.7 155.4,10.31 153.97,10.31 153.52,9.86 v2(153.52,9.7)
N17457344: length 4.3
  TOP w0.305: U10.4 20.99,73.47 v2(20.72,73.2)
  BOTTOM w0.127: v2(20.72,73.2) 21.49,73.2 v1(21.61,73.33)
  BOTTOM w0.305: R592.2 20.1,72.7 19.71,72.31 19.46,72.31 R597.2
  BOTTOM w0.381: v2(20.72,73.2) 20.47,72.95 R592.2
N17457353: length 1.7
  TOP w0.127: U10.15 23.01,76.38 23.42,76.78 R236.2
N17457355: length 5.2
  TOP w0.305: v2(18.95,71.3) v1(18.95,72.01) 18.95,72.06 19.49,72.61 U10.5
  BOTTOM w0.508: R596.2 19.08,71.04 18.95,71.17 v2(18.95,71.3)
N17457385: length 2.7
  TOP w0.127: v1(21.49,77.01) 21.86,77.39 R235.1 22.4,76.76 22.51,76.65 U10.16
N17457428: length 2.2
  TOP w0.305: v2(24.69,72.82) 24.69,73.08 24.88,73.26 U10.9
  BOTTOM w0.127: v2(24.69,72.82) v1(23.98,72.82)
  BOTTOM w0.508: v2(24.69,72.82) 24.7,72.83 R595.1
N17580566: length 7.5
  TOP w0.102: R227.1 38.46,82.59 38.16,82.88 38.16,83.24
  TOP w0.127: 38.16,83.24 38.16,83.5 37.61,84.06 37.04,84.06 R213.1 ; R227.1 38.76,81.95 39.16,81.54 v2(39.44,81.54) 39.79,81.54 40.8,80.53 U11.122
N17595064:
  vias: v1(15.26,6.78) v2(16.41,6.66) v2(17.63,36.01) v2(17.59,35.36) v2(18.18,35.63) v2(18.79,36.02) v2(18.79,35.34)
N17600271: length 3.7
  BOTTOM w0.127: PC216.2 45.12,47.51 v1(44.6,48.03) 44.37,47.8 42.82,47.8 42.61,48.02 PU12.5
N17605466: length 1
  BOTTOM w0.127: PC204.2 PR177.2
N17605675: length 2
  BOTTOM w0.127: v2(44.02,45.16) PC214.2 44.01,46.15 PR182.2
N17644052: length 248.3
  TOP w0.127: v2(45.57,68.19) 45.57,68.12 45.58,68.11 45.58,67.83 44.4,66.65 U11.48 ; v2(52.83,61.19) 53.11,61.19 53.16,61.24 54.1,61.24 54.68,61.82 v1(54.68,62.03) 55.77,63.11 R291.1 ; v2(194.97,56.82) 193.17,56.82 192.84,57.16 192.84,59.21 192.45,59.59 191.44,59.59 190.42,60.6 188.14,60.6 187.09,61.65 182.14,61.65 182.01,61.52 R296.1
  IN1 w0.14: v2(194.97,56.82) 194.49,56.34 194.49,53.09 193.68,52.28 193.68,50.29 193.14,49.75 193.14,45.34 189.74,41.94 189.74,38.35 190.04,38.05 190.04,34.65 190.36,34.32 190.36,33.9 190.15,33.69 190.06,33.69 187.6,31.23 187.59,31.23 186.48,30.12 186.48,27.73 184.06,25.31 183.13,24.38 183.13,22.94 181.12,20.94 180.83,20.94 177.11,17.22 173.63,17.22 173.07,16.66 172.01,16.66 171.14,15.79 166,15.79 165.91,15.88 163.25,15.88 162.59,16.53 159.52,16.53 159.31,16.74 153.56,16.74 153.09,16.27 140.76,16.27 138.88,14.39 117.9,14.39 116.33,15.96 111.14,15.96 108.12,12.94 96.26,12.94 95.16,14.05 91.13,14.05 90.04,15.13 81.56,15.13 81.24,15.46 73.15,15.46 63.35,25.26 63.35,26.34 60.53,29.15 60.53,51.43 56.94,55.01 56.94,55.7 56.95,57.02 52.83,61.14 v2(52.83,61.19) 52.83,62.89 52.09,63.63 52.09,65.41 50.57,66.93 47.56,66.93 46.53,67.96 45.8,67.96 v2(45.57,68.19)
N17644703: length 7.8
  TOP w0.127: U10.6 23.01,71.94 22.99,71.91 ; 22.99,71.91 22.66,71.58 v1(21.87,71.58) ; 22.99,71.91 23.3,71.59 26.49,71.59 R274.1 27.33,72.18 28.09,72.94 R275.1
N17679694: length 9.5
  TOP w0.508: R257.2 192.87,76.26 192.48,75.87 191.47,75.87 191.02,76.31 C356.1 190.4,77.13 ; 190.4,77.13 190.4,79.05 189.38,80.06 ; 190.4,77.13 190.29,77.02 189.39,77.02 189.2,76.84 v1(188.92,76.84) 188.74,77.02 C355.2
N18045822: length 5.7
  TOP w0.127: v1(21.99,149.78) 21.99,149.79 EC19.1
  TOP w0.508: EC19.1 20.47,149.79 20.23,150.04 R124.1 R125.1 R127.1 R128.1
N18129791: length 19.5
  TOP w0.127: U20.30 188.83,13.01 v2(189,13.18) ; R431.2 174.81,7.43 175.03,7.65 v2(175.03,7.65)
  IN2 w0.14: v2(175.03,7.65) 175.03,7.65 175.03,7.66 175.37,8 181.35,8 182.89,9.54 186.8,9.54 189,11.74 v2(189,13.18)
N18283361: length 2.6
  BOTTOM w0.254: C798.2 191.88,21.27 192.23,21.62 192.23,22.02 v1(192.56,22.35) 192.81,22.1 R622.1
N18283364: length 2.7
  BOTTOM w0.254: C799.2 194.83,21.27 194.64,21.46 194.64,22.17 v1(194.46,22.35) 193.95,21.84 R623.1
N18673300: length 1.3
  TOP w0.635: C8738.2 R604.2
N18680854: length 5.8
  BOTTOM w0.127: R7465.1 40.66,181.92 40.03,181.28 Q7030.3 ; R7465.1 42.31,181.15 42.19,181.03 R7466.2 ; R7465.1 43.02,182.62 v2(43.02,182.8)
N18680937: length 8.9
  BOTTOM w0.127: v1(51.33,182.55) 50.44,181.66 Q7031.2 46.63,181.66 46.38,181.41 45.23,181.41 C7748.2 R7465.2
N18773425: length 6.9
  TOP w0.127: v2(194.38,96.44) 194.84,96.9 v1(194.84,98.37) 195.2,98.73 Q37.3
  BOTTOM w0.127: R532.2 192.55,97.97 194.08,96.44 v2(194.38,96.44)
N19250842: length 8.5
  TOP w0.127: v2(20.61,107.79) 21.41,107.79 R156.1 20.88,108.48 20.88,113.43 21.48,114.04 U8.25
N19299291: length 12.1
  TOP w0.127: v2(145.92,107.51) 145.92,109.3 v1(145.57,109.65) 145.25,109.97 145.25,114.73 R148.1
  BOTTOM w0.076: 146.14,106.69 146.2,106.63 146.2,106.23 146.6,105.82 146.6,105.42 146.61,105.4 146.62,105.36 146.62,105.35 146.63,105.34 146.66,105.26 146.66,105.11 146.62,105.03 146.57,104.9 146.57,104.8 146.66,104.61 146.66,104.54 146.99,104.21 U25.C35
  BOTTOM w0.127: 146.14,106.69 146.14,107.3 v2(145.92,107.51)
N19299303: length 9.5
  TOP w0.127: v2(146.39,107.94) 146.17,108.15 146.17,110.8 v1(145.95,111.02) 145.69,111.28 R152.1
  BOTTOM w0.076: 146.39,106.73 146.39,106.27 146.77,105.89 146.77,105.45 146.83,105.29 146.83,105.07 146.77,104.96 146.77,104.94 146.77,104.79 146.83,104.65 146.91,104.57 147.17,104.57 147.62,104.12 U25.C34
  BOTTOM w0.127: 146.39,106.73 v2(146.39,107.94)
N19299315: length 13.5
  TOP w0.127: v3(164.8,80.97) 165.24,80.53 165.24,79.42 R239.1
  IN2 w0.14: v3(164.8,80.97) 165.25,81.42 165.25,82.11 164.6,82.76 164.6,84.77 164.08,85.29 164.08,88.67 163.12,89.64 v2(162.71,89.64)
  BOTTOM w0.076: U25.AK8 163.39,89.28 163.07,89.28 v2(162.71,89.64)
N19299327: length 13.4
  TOP w0.127: v2(164.79,80.33) 164.33,80.33 v1(163.96,79.96) 164.43,79.48 164.43,78.6 164.86,78.16 R245.1
  IN2 w0.102: 163.67,84.53 163.11,85.09 163.11,85.54 163.32,85.75 163.47,85.75 163.65,85.93 163.65,88.29 v2(163.21,88.74)
  IN2 w0.14: 163.67,84.53 163.67,83.03 164.31,82.4 164.31,80.81 v2(164.79,80.33)
  BOTTOM w0.076: v2(163.21,88.74) 163.53,88.41 U25.AL8
N19352741: length 27.2
  TOP w0.127: R332.1 R333.1 151.71,38.35 v1(151.71,37.52) 151.42,37.23 151.42,30.94 150.79,30.31 150.79,26.94 150.5,26.65 R367.1 R366.1 148.61,25.57 148.61,24.57 148.23,24.19 140.37,24.19 139.72,23.55 Q24.1
N19395477: length 14.9
  TOP w0.254: v2(192.76,39.93) 192.9,39.79 192.9,39.08 192.72,38.9 U14.14
  BOTTOM w0.508: R7470.1 185.43,31.38 v1(187.4,33.35) 187.4,34.11 188.53,35.24 188.53,37.53 190.99,39.99 192.7,39.99 v2(192.76,39.93)
N20069633: length 2.4
  TOP w0.127: PR223.1 55.74,54.98 v1(55.7,54.94) 55.88,54.76 PD11.2
N20070129: length 3.9
  TOP w0.127: PR223.2 PR224.1 56.52,57.82 v1(56.59,57.89) 56.84,57.89 57.25,57.48 PQ40.2
N20718638: length 8.8
  TOP w0.127: PR248.1 51.59,163.42 v1(51.33,163.42) 51.33,163.32 PQ44.3 PR247.2 ; PR248.1 52.98,162.74 PQ43.3 ; PR248.1 PC250.2
N20718668: length 5.8
  TOP w0.127: PR237.2 45.41,165.04 44.65,164.29 44.3,164.29 44.09,164.08 v1(44.09,163.73) 45.44,163.73 45.69,163.98 PQ41.3
N20722048:
  vias: v2(56.91,181.97)
N20724765: length 3.2
  TOP w0.127: R8515.1 64.7,172.1 65.23,171.58 v1(65.23,171.07) 64.39,170.24 U8021.7
N20796945: length 2.8
  TOP w0.254: R7478.2 143.73,10.52 v1(142.72,10.52) 142.72,10.03 143.09,9.66 U22.3
N20796949: length 2.5
  TOP w0.127: v1(142.06,5.16) 143.04,5.16 C1028.1
  TOP w0.254: C1028.1 143.09,5.31 U22.4
N20797376: length 24
  TOP w0.127: R8563.2 v2(154.32,5.13) ; R7487.1 152.56,7.4 152.7,7.54 v2(153.29,7.54) ; v2(169.08,5.72) 169.26,5.9 169.26,7.24 v2(169.34,7.32) 169.08,7.58 Q34.6
  BOTTOM w0.127: v2(169.08,5.72) 168.09,4.72 154.73,4.72 v2(154.32,5.13) 154.22,5.03 153.11,5.03 152.88,5.26 152.88,7.14 v2(153.29,7.54)
N20797384: length 21.6
  TOP w0.127: Q820.3 165.77,8.58 v2(165.38,8.97) ; Q820.6 163.74,7.28 v2(163.32,7.7) ; v2(153.44,5.49) 153.08,5.13 R7482.2 R7479.1 153.24,6.27 153.38,6.13 Q821.6 ; Q821.3 v4(157.66,7.43)
  BOTTOM w0.127: v4(157.66,7.43) 158.28,7.43 159.18,8.33 162.69,8.33 v2(163.32,7.7) 164.11,7.7 v2(165.38,8.97)
  BOTTOM w0.14: v2(153.44,5.49) 155.39,7.43 v4(157.66,7.43)
N20797388: length 6
  TOP w0.127: R8564.2 167.49,6.52 167.49,7.75 167.31,7.92 167.31,8.71 166.65,9.37 R7481.1 167.53,9.95 167.78,10.2 Q34.3
N20797417: length 5
  TOP w0.127: R8564.1 167.26,7.07 167.26,7.65 166.98,7.93 Q820.2 Q820.5
N20797556: length 3.7
  TOP w0.127: Q34.5 Q34.2 168.43,12.12 R7484.2
N20849527: length 6.4
  TOP w0.127: U11.66 53.3,66.13 53.73,65.7 53.73,64.2 R8559.1 54.04,63.36 v1(53.64,62.97) 53.17,62.49 R8558.1
N20856073: length 3.4
  TOP w0.102: C440.2 109.12,39.29 109.52,38.89 110.62,38.89 v1(111.02,39.29)
  TOP w0.508: R336.1 C440.2
N20880871: length 2.5
  TOP w0.127: v1(153.31,24.44) 153.45,24.57 C540.2
  TOP w0.508: R371.2 C540.2
N21162142: length 3.9
  TOP w0.127: R8563.1 155.34,5.52 155.34,6.78 ; 155.34,6.78 Q821.5 ; 155.34,6.78 Q821.2
N21181483: length 2.2
  TOP w0.127: R91.1 184.44,159.21 184.41,159.18 EC10.1 184.41,157.67 v1(184.43,157.66)
N21244249: length 1.3
  TOP w0.127: R272.2 34.97,74.09 34.86,74.21 C365.1
N21579333: length 2.4
  TOP w0.127: R349.1 111.01,34.08 v1(110.77,33.83)
  TOP w0.508: C468.2 R349.1
N21693128: length 3.7
  TOP w0.127: v1(64.92,15.16) 64.92,14.66 R407.2 63.78,14.53 U19.32
N21768474: length 3.2
  TOP w0.127: R280.2 C370.2 R276.1 v1(23.14,98.22)
N21829998: length 11
  TOP w0.127: U11.108 46.4,84.66 47.78,86.03 49.81,86.03 50.06,85.78 D4.2 50.06,84.13 v1(50.19,84)
N21834644: length 4.3
  TOP w0.127: 55.01,85.9 55.01,83.75 R221.1 R229.1 55.01,81.59 v1(55.01,81.59)
N21836538: length 7.8
  TOP w0.127: v2(58.8,60.99) 58.27,61.52 D8.2 58.05,62.24 57.66,61.85 56.33,61.85 R294.2 C383.2 R298.1 R304.1
N21913817:
  vias: v1(169.21,123.47)
N22163425: length 3.1
  TOP w0.127: R386.1 v1(111.48,20.75) 112.03,21.3 U16.4
N22190399: length 6.9
  TOP w0.127: R270.1 85.46,74.07 84.76,74.07 83.97,74.85 v1(83.59,74.85) 82.19,74.85 81.06,73.72 CN8.1
N23232206: length 4
  TOP w0.127: CN22.5 175.8,159.94 R94.1 177.05,159.7 v1(177.06,159.69)
N23234772: length 12.8
  TOP w0.508: v2(17.04,177.11) v1(16.15,177.11) 12.22,177.11 11.31,178.02 CN21.13
  BOTTOM w0.508: R439.2 17.52,177.6 v2(17.04,177.11)
N23234774: length 9.8
  BOTTOM w0.508: CN21.14 v1(13.74,159.38) 14.94,159.38 15.24,159.08 R454.1
N23235545: length 10
  TOP w0.508: R119.1 15.59,157.73 v2(16.15,158.29) ; R131.1 15.39,140.15 15.39,139.12 v2(16.15,138.35) 15.75,137.95 v1(15.75,137.47) R140.1 ; R101.1 15.57,159.77 16.28,159.07 v2(16.28,159.06)
  vias: v5(20.47,169.06) v5(20.47,168.2) v5(21.23,169.09) v5(21.23,168.2)
N24212148: length 5.1
  TOP w0.127: R267.2 194.09,74.23 v1(194.21,74.35)
  TOP w0.508: Q18.3 191.03,75.24 192.82,75.24 R257.1 R267.2
N26062304: length 3.3
  BOTTOM w0.508: PC206.2 46.26,49.45 v1(47.14,48.57) 47.27,48.44 47.27,47.07 PR180.1
N26069681: length 1.7
  TOP w0.127: PU8.12 69.25,31.19 PC109.1
N26069683: length 1.7
  TOP w0.127: PC111.1 69.25,30.39 PU8.10
N26069863: length 4.2
  TOP w0.127: PR135.2 63.66,27.85 v1(63.65,27.84)
  TOP w0.178: PR135.2 PC112.1 64.28,30.39 PU8.5
N26069874: length 5.7
  TOP w0.127: v1(61.75,32.69) 62.13,32.69 62.51,32.31 63.31,32.31 63.43,32.44 63.43,32.44 63.48,32.49 63.48,32.64 PR124.1 PC108.1 63.88,31.59 64.91,31.59 65.31,31.19 PU8.3
N26073897: length 2.8
  TOP w0.127: PU5.12 69.05,41.35 v1(69.31,41.61) 69.47,41.45 PC82.1
N26073915: length 2.8
  TOP w0.127: PC86.1 69.44,40.44 v1(69.31,40.31) 69.08,40.55 PU5.10
N26074092: length 5.4
  TOP w0.127: v1(62.13,37.9) 62.93,37.9 63.66,38.63 PR118.2 PC87.1 64.69,39.93 65.31,40.55 PU5.5
N26074102: length 4.6
  TOP w0.127: PU5.3 64.4,41.35 PC80.1 63.66,43.15 PR113.1 63.66,43.17 63.66,43.65 v1(64.16,44.15)
N26154108: length 3
  TOP w0.254: PR103.2 197.64,65.88 v2(197.1,66.42) 196.13,66.42 v2(195.95,66.6)
  BOTTOM w0.254: v2(195.95,66.6) 195.9,66.6 195.8,66.7 PU10.6
N26154172: length 16.3
  TOP w0.127: PR109.2 185.93,68.27 v1(186.71,67.49) 187.98,66.22 188.42,66.22 191.91,62.72 192.81,62.72 192.93,62.6 193.37,62.6 193.64,62.34 193.64,61.84 192.94,61.14 PR108.1
N26154190: length 2.3
  TOP w0.381: v2(195.22,66.09) 195.22,66.85 v1(195.35,66.98) 195.54,67.17 196.12,67.17 196.24,67.28 PR102.2
N26154214: length 4.8
  TOP w0.381: PR106.1 191.13,62.85 191.02,62.85 v1(190.52,63.35) 190.07,63.8 190.07,63.99 189.74,64.32 PC71.2 189.24,64.32 188.56,65 PU4.1
N26154223:
  vias: v1(184.91,63.65)
N26154331: length 3.3
  TOP w0.381: PU4.5 187.22,62.15 188.24,61.14 v1(188.49,61.14) PR107.1
N27387581: length 2.6
  TOP w0.127: U17.3 185.41,22.23 v2(185.41,23.52)
  TOP w0.508: U17.3 184.87,22.21 184.8,22.14 R374.2
N27387585: length 1.2
  TOP w0.508: C548.1 184.4,19.81 U17.4
N27387907: length 6.3
  TOP w0.127: v1(173.79,8.41) 175.41,8.41 Q31.3
  TOP w0.254: Q31.3 177.06,7.67 177.32,7.41 C583.1 R432.2
N27595117: length 3.8
  TOP w0.254: C586.1 C587.2 187.86,9.07 v2(187.78,9.15) 187.56,9.37 187.56,10.29 187.77,10.51 U20.25
N27595147: length 1.9
  TOP w0.127: R411.1 179.7,12.37 180.34,13.01 U20.7
N27595159: length 4.2
  TOP w0.203: C588.1 182.65,8.69 182.92,8.96 185.41,8.96 185.68,9.22 U20.21
N27595207: length 12
  TOP w0.254: R436.1 186.33,4.88 186.55,4.66 189.47,4.66 189.69,4.88 189.69,7.44 190.04,7.79 190.04,8.71 v1(190.78,9.45) 191.93,10.6 C574.1 C571.1
N27595246: length 3.4
  TOP w0.203: U20.22 186.18,9.17 185.67,8.66 183.99,8.66 183.79,8.46 R429.1
N27595457: length 4.9
  TOP w0.127: U20.1 180.33,16.01 180.27,16.08 180.27,18.38 v1(180.16,18.49) 179.93,18.72 179.93,19.08 180.49,19.63 C544.1
N27595642: length 4
  TOP w0.127: Q29.2 170.33,8.74 169.99,9.08 169.99,10.81 169.59,11.21 R408.1
N27595733: length 5.3
  TOP w0.254: U20.34 188.54,15.01 188.82,15.29 189.38,15.29 v1(189.76,14.91) 190.34,14.91 191.26,15.83 191.96,15.83 C563.2
N28189735: length 1.9
  TOP w0.127: v2(195.82,20.36) R388.2
  TOP w0.254: R388.2 194.08,20.36 C546.1
N28189738: length 2.2
  TOP w0.127: R387.2 191.57,20.36 v2(190.95,20.98)
  TOP w0.254: C545.1 192.68,20.36 R387.2
N33402405: length 3.5
  TOP w0.127: PR17.2 84.27,179.78 v1(84.27,178.97)
  TOP w0.254: PR17.2 83.92,179.63 PQ34.3
N33402410: length 9.4
  TOP w0.254: PR17.1 84.92,179.91 PR16.2 ; PR16.2 84.92,181.01 84.37,181.56 83.17,181.56 PR213.1 ; PR16.2 85.19,181.27 85.19,181.76 85.9,182.47 v1(86.11,182.47) 86.4,182.47 PC233.1 87.92,181.62 PU1.6
N33402439: length 4.7
  TOP w0.127: PR18.1 89.12,176.95 ; 89.12,176.95 PR214.1 ; 89.12,176.95 89.12,177.76 v2(88.97,177.91) 88.47,178.41 88.47,179.38 88.71,179.62 PU1.10
N33402467: length 6.7
  TOP w0.127: PR21.2 81.02,175.08 v1(80.02,175.08)
  TOP w0.254: PR21.2 PR20.2 81.12,177.15 PQ34.2 80.64,177.63 PQ35.3
N33402472: length 8.1
  BOTTOM w0.127: v2(71.8,174.5) 71.99,174.31 PR206.2 72.16,174.79 72.16,175.95 71.89,176.23 70.38,176.23 70.14,175.98 70.14,175.88 ; PR207.1 69.17,176.07 69.95,176.07 70.14,175.88 ; 70.14,175.88 PQ38.6
  BOTTOM w0.254: PR207.1 68.89,175.96 68.06,176.79 PR209.2
N33402473: length 5.2
  BOTTOM w0.127: PR209.1 67.47,176.01 66.98,175.52 v1(66.97,175.52)
  BOTTOM w0.254: PR209.1 68.44,175.47 69.24,175.47 69.98,174.73 70.51,174.73 70.79,175.01 PQ38.5
N33402478: length 2.1
  BOTTOM w0.254: PQ38.1 70.14,177.41 69.53,178.01 v2(69.47,178.01) 69.43,178.01 69.42,178 PR208.1
N33402480: length 4.9
  BOTTOM w0.127: PQ38.2 70.79,176.66 70.61,176.48 69.72,176.48 69.46,176.74 PR207.2 68.49,177.32 67.3,177.32 v1(66.96,176.97)
N33402502: length 2.9
  TOP w0.127: PR14.1 109.44,178.51 110.01,179.08 v1(110.01,179.1)
  TOP w0.508: PC235.1 109.02,180.36 PR14.1
N33402505: length 4.1
  TOP w0.127: PR215.2 79.87,182.12 v1(79.77,182.21)
  TOP w0.254: PQ35.2 78.93,180.88 78.54,181.27 ; 78.54,181.27 PR215.2 ; 78.54,181.27 PR216.2
N33402710: length 3.9
  TOP w0.508: PR7.2 118.99,180.11 v1(117.72,180.11) 116.92,180.11 116.23,180.8 PQ1.3
N33402820: length 13
  TOP w0.127: PQ18.3 v1(47.14,91.92) 46.81,91.92 v2(45.85,92.89) ; PQ17.5 42.82,95.94 42.57,96.19 41.86,96.19 v2(41.55,95.89) 41.48,95.81 PR66.2 40.93,95.44 40.79,95.3 40.28,95.3 40.15,95.17 PR64.1
  BOTTOM w0.127: v2(45.85,92.89) 42.85,95.89 v2(41.55,95.89)
N33402831: length 5.1
  TOP w0.127: v1(45.49,96.83) 45.49,96.19 44.97,95.67 PR63.1 PR68.1 43.73,94.39 43.47,94.13 PQ17.3
N33402842: length 2.2
  TOP w0.127: PR64.2 41.55,94.79 41.93,94.41 42.06,94.41 42.17,94.52 PQ17.6
N33402848: length 7.4
  TOP w0.127: PR62.1 37.2,97.2 PQ14.3 ; PR62.1 34.45,97.2 v1(34.31,97.33) ; PR62.1 PR65.2 36.22,95.94 36.62,96.34 37.21,96.34 37.36,96.19 PQ16.5
N33402861: length 11
  TOP w0.127: PQ16.3 38.01,92.65 37.82,92.46 37.82,91.88 38.08,91.62 38.46,91.62 39.14,92.31 40.53,92.31 40.59,92.25 PR69.1 41.76,92.89 41.76,94.16 41.58,94.34 40.64,94.34 40.08,93.78 PR67.1 39.91,94.19 39.38,94.72 v1(39.08,94.72)
N33402863: length 8.8
  TOP w0.127: PQ16.6 36.3,95.31 35.61,94.62 33.53,94.62 33.04,95.1 v1(33.04,95.68) 33.04,97.08 33.94,97.98 PR62.2
N34547300: length 3.4
  TOP w0.127: PC106.1 93.63,38.66 93.75,38.54 PR126.2 94.9,38.54 95.63,39.28 PU7.4
N34547582: length 1
  TOP w0.127: PC90.1 v1(94.38,46.66)
N34547691: length 2.1
  BOTTOM w0.508: PR186.1 101.24,49.35 v1(101.4,49.2) 101.45,49.14 PC217.2
N34551022: length 5.1
  TOP w0.127: PU7.10 98.66,37.55 98.83,37.39 99.72,37.39 100.15,36.96 101.29,36.96 v1(101.7,36.55) 102.13,36.12 PR132.2
N34551161: length 2.4
  TOP w0.203: PU7.3 94.82,39.68 94.64,39.86 v2(94.61,39.86) 94.26,39.86 PR123.1
N41915855: length 2.3
  BOTTOM w0.127: PC168.2 112.68,97.85 v1(112.67,97.84)
  BOTTOM w0.508: PR161.1 113.03,99.71 112.68,99.37 PC168.2
N41915908: length 44.4
  TOP w0.254: PR75.2 87.99,86.95 87.99,89.67 89.76,91.44 v1(89.76,92.25) 89.76,93.47 100.42,104.13 101.05,104.13 101.75,104.83 101.75,106.1 102.89,107.24 105.69,107.24 106.07,107.62 106.07,108.76 107.08,109.78 110.77,109.78 112.04,108.51 v2(112.04,105.84)
  BOTTOM w0.254: v2(112.04,105.84) PR159.1
N41916085: length 3.5
  TOP w0.127: v1(89.18,77.9) 89.82,77.26 PR98.1
  TOP w0.254: PR99.2 91.21,76.24 PC62.2 PR98.1
N41916105: length 33.3
  TOP w0.254: PR85.2 86.53,81.72 PR90.2 86.13,82.86 v2(86.26,82.98)
  IN1 w0.254: v2(100.61,102.06) 99.72,102.06 86.26,88.59 86.26,86.28 86.76,85.78 86.76,83.36 86.38,82.98 v2(86.26,82.98)
  BOTTOM w0.254: v2(100.61,102.06) 105.02,102.06 PR160.2
N41916134: length 2.4
  TOP w0.127: PC63.1 93.12,76.5 v1(93.5,76.12)
  TOP w0.254: PC63.1 93.24,77.26 PR95.2
N41916242: length 3.7
  TOP w0.203: v2(90.63,84.94) 90.65,84.94 90.6,84.89 90.69,84.8 PU3.16
  BOTTOM w0.381: v2(90.63,84.94) 90.07,84.38 v1(90.07,83.87) 90.82,83.87 PR164.2
N122990257: length 3.4
  TOP w0.127: v1(67.97,63.75) 68.59,64.38 R288.2 68.56,64.73 CN8.35
N168403930: length 3.8
  TOP w0.127: C357.1 35.08,76 35.38,75.69 35.38,74.11 35.76,73.73 U11.12
N172588423: length 2
  TOP w0.127: TP12.1 187.73,59.36 187.38,59.01 U13.9
N212352420: length 1.3
  BOTTOM w0.508: PC199.2 37.74,52.3 37.62,52.17 PR176.1

## Copper pours and planes (outline as drawn)
1.05VMOD_OND on TOP (solid shape): 176.7,120.51 177.26,119.95 177.26,119.32 177.05,119.11 177.05,118.7 177.01,118.67 176.57,118.67 176.09,119.14 176.09,120.73 176.48,120.73
1.05VMOD_ONG on TOP (solid shape): 175.41,131.88 175.41,130.48 175.28,130.35 174.14,130.35 173.89,130.1 173.89,128.37 172.74,127.23 171.91,127.23 171.68,127 171.68,125.83 171.73,125.78 172.11,125.4 172.74,125.4 173.25,124.89 173.25,123.8 173.24,123.76 173.2,123.75 171.52,123.75 171.49,123.76 171.47,123.8 171.47,124.64 171.22,124.89 171.22,126.04 171.22,127.36 171.22,127.38 171.25,127.41 171.25,127.72 171.65,128.12 171.66,128.13 171.88,128.27 171.96,128.52 171.96,129.34 172.74,130.12 172.74,131.84 172.92,132.02 175.28,132.02
+0.65V_DDR_VTT on TOP (solid shape): 175.09,45.25 175.09,43.12 175.65,42.56 175.66,42.54 175.66,42.52 175.66,41.66 175.56,41.55 172.87,41.55 172.74,41.68 172.74,43.49 172.87,43.61 173.25,43.61 174.01,44.37 174.01,45.01 174.29,45.29 175.06,45.29
+0.65V_DDR_VTT on TOP (solid shape): 96.59,41.88 97.05,41.88 97.17,41.77 97.17,40.78 97.1,40.71 95.64,40.71 95.6,40.67 95.6,40.23 95.64,40.19 95.77,40.19 95.77,40.18 96.72,40.18 96.75,40.15 96.75,39.97 95.77,39.97 95.77,39.9 95.07,39.9 94.53,40.44 94.12,40.44 94,40.56 94,41.73 94.31,42.04 96.44,42.04
+0.65V_DDR_VTT on TOP (solid shape): 173.36,35.63 173.39,35.58 173.43,35.55 173.5,35.5 173.59,35.47 173.6,35.46 173.71,35.36 173.71,34.85 173.83,34.72 176.36,34.72 176.39,34.72 176.39,33.63 176.37,33.59 176.33,33.58 176.04,33.58 175.88,33.51 175.81,33.35 175.81,33.22 175.81,32.66 175.75,32.52 175.75,32.36 175.75,32.35 175.75,31.24 175.46,30.95 175.46,29.84 175.46,29.82 175.45,29.81 175.41,29.77 173.38,29.77 173.2,29.95 173.2,31.33 173.2,31.33 173.2,31.47 173.55,31.81 173.55,33.82 173.34,34.03 172.82,34.03 172.74,34.1 172.74,35.57 172.82,35.65 173.32,35.65
+0.65V_DDR_VTT on BOTTOM (solid shape): 175.53,35.25 175.53,33.19 174.8,32.46 174.8,32.18 173.96,31.34 173.96,30.33 173.85,30.21 173.42,30.21 173.19,30.45 173.19,31.73 173.19,31.75 173.2,31.76 173.62,32.19 173.63,32.19 174.49,33.05 174.95,33.05 175.17,33.27 175.17,35.25 175.2,35.27 175.51,35.27
+0.65V_DDR_VTT on BOTTOM (solid shape): 176.99,47.7 176.99,46.03 177,46.01 177,44.97 177.33,44.63 177.35,44.53 177.28,44.46 176.49,43.7 176.98,42.73 177.39,42.63 177.8,42.72 177.9,42.72 177.95,42.63 177.95,31.07 177.9,30.98 177.8,30.98 176.48,30.15 177.8,29.32 177.9,29.32 177.95,29.23 177.95,27.28 176.38,25.71 175.74,25.07 175.51,25.07 175.47,25.11 175.47,27.75 175.47,27.84 175.37,27.94 175.37,30.59 175.37,30.59 175.37,30.93 175.98,31.54 175.98,31.64 176,31.65 176,31.74 176.03,31.82 176.11,31.84 176.48,31.98 176.53,32.37 176.52,32.38 176.52,32.48 176.59,32.55 176.59,37.3 175.53,38.36 175.5,38.39 175.49,38.41 175.49,40.67 174.28,41.88 174.27,41.88 173.84,42.3 173.84,45.11 173.85,45.15 173.89,45.16 174.16,45.29 174.26,45.58 174.26,45.6 174.27,45.62 175.17,46.53 175.17,48.76 175.19,48.79 175.23,48.81 175.88,48.81
+0.65V_DDR_VTT on IN1 (solid shape): outline of 845 points within 94.64,30.15 175.34,44.3
+1.05V on TOP (solid shape): 118.64,86.16 118.64,85.78 116.74,83.87 116.74,82.35 116.36,81.97 114.96,81.97 114.7,82.22 114.7,84.89 114.83,85.01 116.36,85.01 117.88,86.54 118.26,86.54
+1.5V on TOP (solid shape): 181.07,67.9 183.03,67.9 183.28,67.65 183.28,65.27 183.09,65.08 181.38,65.08 180.27,66.18 174.96,66.18 174.94,66.19 174.92,66.2 174.46,66.66 174.46,67.43 174.53,67.5 175.72,67.5 176.21,68 180.98,68
+1.05V on TOP (solid shape): 173.96,125.27 175.99,125.27 176.75,124.51 177.06,124.51 177.29,124.28 177.29,124.28 180.06,121.52 180.06,112.7 179.71,112.35 178.38,112.35 178.35,112.35 178.33,112.37 172.27,113.83 171.07,107.71 171.2,107.53 171.35,107.36 171.35,105.59 170.58,104.83 168.93,104.83 168.55,105.21 168.55,113.72 172.34,117.5 177.11,117.5 177.88,118.27 177.88,118.77 177.83,118.83 177.8,118.91 177.76,118.97 177.7,119.04 177.63,119.09 177.5,119.22 177.5,120.13 176.25,121.39 171.55,121.39 171.35,121.59 171.35,122.99 171.98,123.62 173.38,123.62 173.51,123.75 173.51,124.89 173.89,125.27
+1.05V on BOTTOM (solid shape): 182.52,81.56 182.52,80.59 181.24,79.31 181.24,78.81 179.39,76.96 179.3,76.96 179.25,77.01 179.25,78.68 179.47,78.9 179.47,82 179.5,82.03 180.97,82.03 180.98,82.04 182.04,82.04
+1.5V on BOTTOM (solid shape): 78,50.85 78,48.23 78.15,48.08 85.11,48.08 85.12,48.09 85.21,48.09 85.4,48.27 85.4,50.41 85.43,50.44 85.87,50.44 85.9,50.41 85.9,48.25 86.38,47.77 86.38,46.91 86.05,46.58 71.73,46.58 71.12,47.19 65.81,47.19 65.4,47.6 65.4,50.39 65.9,50.39 65.9,48.38 66.2,48.08 77.01,48.08 77.2,48.27 77.23,48.27 77.23,48.3 77.29,48.36 77.29,50.71 77.29,50.72 77.31,50.82 77.3,50.92 77.3,50.95 77.31,50.97 77.49,51.16 77.7,51.16
+1.05V on BOTTOM (solid shape): 163.13,92.24 163.2,92.21 163.23,92.16 163.26,91.9 163.45,91.72 163.65,91.52 163.65,91.36 163.81,91.2 163.81,91.08 163.81,91.03 163.81,90.82 163.8,90.79 163.79,90.77 163.73,90.67 163.73,90.56 163.73,90.55 163.72,90.53 163.67,90.48 163.65,90.46 163.62,90.46 163.59,90.47 163.54,90.47 163.49,90.47 163.44,90.46 163.38,90.44 163.21,90.44 163.16,90.49 163.06,90.74 162.8,90.85 162.73,90.84 162.67,90.82 162.6,90.82 162.54,90.87 162.49,90.94 162.42,91 162.37,91.07 162.4,91.16 162.48,91.24 162.5,91.24 162.7,91.38 162.75,91.62 162.75,91.63 162.75,92.16 162.82,92.24
+1.05V on BOTTOM (solid shape): outline of 95 points within 153.48,90.61 156.14,93
+1.5V on IN2 (solid shape): 88.95,47.4 88.95,46.53 88.39,45.97 87.24,45.97 85.39,47.83 85.39,47.99 86.43,47.99 86.44,47.94 86.45,47.88 86.47,47.83 86.5,47.78 86.53,47.74 86.57,47.7 86.62,47.67 86.67,47.64 86.72,47.62 86.77,47.61 86.83,47.61 86.89,47.62 86.94,47.63 86.99,47.65 87.04,47.68 87.08,47.72 87.12,47.76 87.15,47.81 87.17,47.86 87.19,47.91 87.2,47.96 87.2,48.02 87.19,48.08 87.17,48.13 87.15,48.18 87.12,48.23 87.08,48.27 87.04,48.3 86.99,48.33 86.94,48.35 86.89,48.37 86.83,48.37 86.77,48.37 86.72,48.36 86.67,48.34 86.62,48.32 86.57,48.29 86.53,48.25 86.5,48.2 86.47,48.15 86.45,48.1 86.44,48.05 86.43,47.99 85.39,47.99 85.39,48.39 85.62,48.62 87.73,48.62
+1.5V on IN2 (solid shape): outline of 1257 points within 153.26,65.96 175.23,94.92
+1.05V on IN2 (solid shape): outline of 4696 points within 139.76,88.68 179.07,117.96
+1.05V on SVCC (solid shape): outline of 99 points within 153.69,76.82 181.89,100.13
+1.05V_LAN on TOP (solid shape): 19.35,116.74 19.35,116.36 19,116 16.88,116 16.51,116.37 16.51,116.81 16.66,116.97 19.12,116.97
+1.05V_LAN on TOP (solid shape): 18.55,113.86 18.55,112.14 18.79,111.9 18.79,108.28 18.65,108.14 16.01,108.14 15.87,108.28 15.87,109.29 15.73,109.44 15.73,111.41 15.81,111.49 15.9,111.49 15.91,111.49 16.16,111.49 16.94,112.28 16.94,113.79 17.13,113.97 18.44,113.97
+1.05V_LAN on BOTTOM (solid shape): 18.41,116.54 18.41,114.4 19.33,113.49 19.33,109.35 18.9,108.92 16.35,108.92 15.69,109.57 15.69,111.25 15.85,111.4 16.13,111.4 17.19,112.47 17.19,115.23 17.2,115.24 17.22,115.37 17.2,115.5 17.19,115.51 17.19,115.67 16.48,116.38 16.48,116.74 16.74,116.99 17.96,116.99
+1.05V_LAN on IN2 (solid shape): outline of 408 points within 15.68,108.89 29.61,120.75
+1.05V_LAN_REGOUT on TOP (solid shape): 21.23,115.72 21.27,115.7 21.28,115.67 21.28,115.54 21.23,115.49 21.23,114.08 20.69,113.54 20.69,108.34 20.5,108.15 19.27,108.15 19.07,108.35 19.07,112.03 18.76,112.35 18.76,113.93 18.81,113.98 18.96,113.98 19.71,114.73 19.71,115.14 20.29,115.72
+1.05V_MODPHY on TOP (solid shape): outline of 502 points within 162.91,99.24 175.78,121.01
+1.05V_S2 on BOTTOM (solid shape): outline of 357 points within 179.25,64.32 190.82,78.54
+1.35VSUS on TOP (solid shape): outline of 14869 points within 109.55,22.02 158.34,90.84
+1.35VSUS on BOTTOM (solid shape): outline of 682 points within 103.02,23.98 152.2,79.43
+1.35VSUS on IN1 (solid shape): 111.58,60.53 111.58,53.24 111.55,53.16 111.47,53.14 111.07,52.82 111.35,52.39 111.37,52.37 111.39,52.34 111.37,52.3 111.36,52.29 111.36,49.92 111.17,49.73 106.58,49.73 105.69,50.62 105.69,54.53 103.02,57.2 103.02,58.98 103.02,59 103.04,59.02 106.53,62.51 109.6,62.51
+1.35VSUS_S on TOP (solid shape): 105.79,54.63 105.79,44.45 105.51,44.17 101.93,44.17 101.78,44.32 101.78,48.44 103.21,49.87 103.21,52.18 102.08,53.31 102.08,54.38 101.78,54.69 101.78,55.91 101.93,56.06 104.37,56.06
+1.35VSUS_S on BOTTOM (solid shape): 104.67,55.14 104.67,54.66 104.54,54.53 104.54,54.49 104.53,54.47 104.53,53.84 104.61,53.84 104.8,53.65 105.18,53.65 106.58,52.25 106.58,48.82 105.18,47.42 105.18,41.12 104.87,40.82 101.47,40.82 99.59,42.7 98.89,42.7 98.24,43.35 98.24,47.14 99.53,48.42 102.53,48.42 103.15,49.04 103.15,52.55 102.84,52.86 102.23,52.86 101.78,53.31 101.78,55.83 101.71,55.91 101.32,55.91 101.17,56.06 101.17,56.82 101.32,56.97 102.84,56.97
+1.35VSUS_S on IN1 (solid shape): 105.13,54.55 105.13,44.48 104.67,44.02 101.93,44.02 101.4,44.55 101.4,49.58 101.78,49.96 101.78,55.75 102.08,56.06 103.62,56.06
+1.35VSUS_S on IN2 (solid shape): 105.29,54.68 105.29,44.79 104.52,44.02 102.08,44.02 101.78,44.32 101.78,55.75 102.23,56.21 103.76,56.21
+3.3VS5_S on BOTTOM (solid shape): 59.21,41.45 59.21,40.6 58.68,40.08 58.68,39.58 58.51,39.4 58.48,39.41 58.06,38.86 58.75,38.91 58.83,38.99 59.38,38.99 59.69,39.29 60.09,39.29 60.35,39.04 60.35,38.28 60.22,38.15 57.81,38.15 57.38,38.58 49.73,38.58 48.26,40.06 46.08,40.06 45.87,40.27 45.87,44.12 46.12,44.37 56.28,44.37
+3V on TOP (solid shape): 16.94,73.16 16.94,71.01 16.81,70.88 15.95,70.88 15.87,70.96 15.87,73.14 15.97,73.24 16.86,73.24
+3V on TOP (solid shape): 22.88,94.79 22.88,92.89 22.76,92.76 20.34,92.76 20.22,92.89 20.22,94.29 20.47,94.54 22.12,94.54 22.5,94.92 22.76,94.92
+3V on TOP (solid shape): 114.2,24 114.2,23.17 114.1,23.06 112.44,23.06 112.32,23.19 110.46,23.19 110.34,23.32 110.34,24.03 110.46,24.16 114.04,24.16
+3V on TOP (solid shape): 84.22,57.2 84.22,55.8 83.97,55.55 82.32,55.55 81.3,56.57 81.3,57.33 81.43,57.46 83.97,57.46
+3V on TOP (solid shape): 75.84,34.84 75.84,32.51 75.67,32.33 73.7,32.33 72.15,30.79 71.27,30.79 71.14,30.91 71.14,31.67 71.14,31.68 71.14,31.87 70.64,32.37 70.64,34.71 70.9,34.98 75.7,34.98
+3V on TOP (solid shape): 182.14,51.66 182.14,49.58 181.89,49.33 181,49.33 180.74,49.58 180.74,50.93 178.09,53.58 173.83,53.58 173.39,54.02 173.39,55.28 173.82,55.7 173.83,55.71 173.86,55.72 174.14,55.83 174.25,56.11 174.26,56.15 174.3,56.19 177.62,56.19
+3V on TOP (solid shape): 184.06,74.68 184.06,73.02 183.89,72.85 181.16,72.85 180.11,71.81 179.47,71.81 179.46,71.79 179.43,71.8 179.08,71.7 178.98,71.34 178.98,71.31 178.84,71.17 178.84,71.04 178.33,71.04 178.08,71.3 178.08,71.5 178.33,71.75 178.33,73.21 178.4,73.27 178.4,73.52 180.17,73.52 181.51,74.85 183.88,74.85
+3V on TOP (solid shape): 175.23,99.34 175.34,99.22 175.42,99.22 175.48,99.21 175.6,99.21 175.65,99.22 175.94,99.22 176.41,98.76 176.57,98.75 178.86,98.75 178.96,98.65 178.96,98.35 178.83,98.22 176.27,98.22 175.91,98.47 175.56,98.22 175.16,98.22 174.52,98.86 173.76,98.86 173.63,98.98 173.63,99.62 173.76,99.75 174.82,99.75
+3V on TOP (solid shape): 76.29,25.66 76.29,24.88 76.3,24.87 76.3,23.85 75.31,22.86 75.13,22.86 74.92,22.65 74.91,22.65 74.77,22.57 74.72,22.43 74.72,22.13 74.73,22.06 74.76,22.01 74.76,21.97 74.75,21.94 74.65,21.84 74.14,21.84 73.94,22.05 73.94,22.45 74.09,22.61 74.22,22.61 74.55,22.94 74.61,22.98 74.66,23.04 74.8,23.19 74.8,24.08 74.52,24.36 74.52,25.32 75.06,25.85 76.1,25.85
+3V on TOP (solid shape): 63.02,26.21 63.02,25.45 63.14,25.32 63.16,25.32 63.19,25.32 63.29,25.23 63.39,25.2 63.52,25.2 63.63,25.1 63.63,22.33 63.45,22.15 63.45,21.62 63.47,21.48 63.54,21.37 63.54,21.32 63.5,21.29 63.45,21.29 63.12,20.96 62.83,20.96 62.79,20.99 62.77,20.99 62.69,21.08 62.69,22.73 62.13,23.29 62.13,24.31 61.75,24.69 60.73,24.69 60.35,25.07 60.35,27.08 60.68,27.41 61.82,27.41
+3V on BOTTOM (solid shape): 16.93,73.04 16.93,71.07 16.89,71.03 15.99,71.03 15.77,71.25 15.77,72.97 15.89,73.09 16.88,73.09
+3V on BOTTOM (solid shape): 43.96,180.96 43.96,180.02 43.85,179.91 43.83,179.91 43.83,178.97 44.4,178.41 44.4,177.49 43.98,177.07 43.58,177.07 42.85,177.8 42.85,180.99 43.01,181.15 43.78,181.15
+3V on BOTTOM (solid shape): 53.74,181.92 53.74,180.78 54.37,180.15 54.37,179.24 54.24,179.12 53.37,179.12 53.31,179.12 52.86,179.12 52.47,179.5 51.59,179.5 51.45,179.65 51.45,181.35 52.13,182.04 53.62,182.04
+3V on BOTTOM (solid shape): 185.37,49.66 192.1,49.66 195.5,46.26 195.5,45.87 195.31,45.69 194.67,45.69 192.2,48.16 185.75,48.16 185.74,48.17 185.33,48.17 184.43,49.07 181.76,49.07 181.65,49.19 181.65,50.86 181.76,50.98 184.05,50.98
+3V on BOTTOM (solid shape): outline of 102 points within 20.22,87.3 27.96,94.67
+3V on BOTTOM (solid shape): outline of 95 points within 73.18,32.23 93.88,39.9
+3V on BOTTOM (solid shape): outline of 1692 points within 46.8,10.11 92.99,27.86
+3V on IN1 (solid shape): 78.15,31.14 78.15,30.79 77.14,29.77 75.92,29.77 73.33,32.36 73.33,34.34 73.61,34.62 74.67,34.62
+3V on IN1 (solid shape): outline of 87 points within 89.08,20.95 106.7,23.8
+3V on IN1 (solid shape): outline of 329 points within 181.63,81.41 188.62,95.31
+3V on IN1 (solid shape): outline of 840 points within 75.08,37.39 89.36,56.39
+3V on IN2 (solid shape): 174.7,99.4 174.7,96.63 173.96,95.89 171.47,95.89 171.35,96.01 171.35,96.19 171.35,96.19 171.35,96.45 171.6,96.7 173,96.7 173.55,97.25 173.55,99.35 173.73,99.53 174.57,99.53
+3V on IN2 (solid shape): outline of 112 points within 104.35,18.82 167.65,23.29
+3V on IN2 (solid shape): outline of 89 points within 173.4,36.12 176.55,56.06
+3V on IN2 (solid shape): outline of 615 points within 179.47,34.29 190.14,83.62
+3V on IN2 (solid shape): outline of 808 points within 69.39,19.99 81.72,34.52
+3V on IN2 (solid shape): outline of 2584 points within 30.38,126.8 70.12,180.77
+3V on IN2 (solid shape): outline of 3421 points within 15.64,14.38 62.74,98.98
+3V_DEEP_SUS on TOP (solid shape): 177.16,72.19 177.41,72.19 177.63,71.97 177.66,71.97 177.68,71.95 177.95,71.68 177.95,71.65 177.95,70.33 177.8,70.18 177.04,70.18 176.17,71.04 174.39,71.04 174.14,70.79 174.14,69.52 173.91,69.29 172.36,69.29 172.29,69.22 172.29,68.71 172.39,68.61 173.79,68.61 173.84,68.55 173.84,68.35 173.79,68.3 172.42,68.3 172.33,68.2 171.78,68.2 171.22,68.76 171.22,71.83 171.38,71.99 171.4,72 171.42,72.01 173.03,72.01 173.15,72 173.27,72.01 173.51,72.01 173.69,72.19 177.16,72.19
+3V_DEEP_SUS on TOP (solid shape): 176.86,92.13 176.94,92.08 176.95,91.99 177.13,91.54 177.61,91.63 177.71,91.67 177.79,91.6 177.83,91.51 177.9,91.43 177.93,91.35 177.9,91.28 177.85,91.21 177.83,91.11 177.83,90.83 177.84,90.75 177.89,90.68 177.89,89.66 178.54,89 178.8,89 179.74,88.06 180.25,88.06 180.46,88 180.66,88.05 180.69,88.06 180.76,88.14 181.33,88.14 181.43,88.04 181.43,87.48 181.12,87.17 180.98,87.17 180.93,87.16 180.88,87.15 180.63,87.15 180.62,87.15 180.49,87.17 180.36,87.15 180.35,87.15 180.1,87.15 180.05,87.16 180,87.17 179.72,87.17 179.68,87.16 179.63,87.15 179.58,87.15 179.53,87.1 179.46,87.07 179.39,87.1 179.35,87.13 179.29,87.16 179.28,87.18 179.28,87.25 178.97,87.56 178.97,87.81 178.82,87.96 178.82,87.98 178.74,88.12 178.59,88.19 178.34,88.19 178.02,88.51 177.75,88.51 177.71,88.52 177.7,88.56 177.7,89.08 177.44,89.33 177.19,89.33 177.06,89.46 177.06,90.09 176.81,90.35 176.3,90.35 176.12,90.53 176.12,90.56 176.13,90.58 176.22,90.9 176.06,91.2 176.06,91.2 176.06,91.54 176.13,91.62 176.15,91.72 176.18,92.1 176.25,92.13
+3V_DEEP_SUS on BOTTOM (solid shape): 187.24,94.63 187.43,94.44 187.7,94.42 187.79,94.4 187.83,94.32 187.83,93.57 186.36,92.1 185.89,91.91 185.44,91.91 184.47,90.94 184.26,90.73 183.54,90.73 183.39,90.88 183.39,90.96 183.39,91.26 183.39,91.41 184.25,92.28 184.25,93.32 184.3,93.37 184.78,93.37 185.34,92.81 185.35,92.8 185.78,92.53 186.09,92.94 186.09,92.98 186.08,93.02 186.1,93.1 186.18,93.15 186.34,93.15 186.5,93.21 186.56,93.37 186.56,93.62 186.73,93.78 186.73,94.67 187.23,94.67
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 181 points within 175.79,84.63 181.25,90.73
+3V_DEEP_SUS on IN1 (solid shape): outline of 492 points within 157.53,91.77 170.53,96.47
+3V_DEEP_SUS on IN2 (solid shape): outline of 810 points within 170.36,75.62 188.95,101.22
+3V_RTC on IN2 (solid shape): 162.41,90.52 162.42,90.42 162.44,90.34 162.44,89.93 162.43,89.9 162.42,89.89 162.33,89.64 162.42,89.38 162.43,89.38 162.44,89.34 162.44,88.76 162.44,88.73 162.42,88.72 162.27,88.41 162.42,88.11 162.44,88.09 162.44,88.06 162.44,87.46 162.42,87.42 162.41,87.41 162.29,87.25 162.28,87.04 162.26,86.96 162.18,86.92 161.69,86.92 161.64,86.95 161.61,87 161.5,87.11 161.45,87.14 161.39,87.16 161.34,87.21 161.34,87.87 161.59,88.19 161.42,88.55 161.42,89.35 161.42,89.36 161.42,90.35 161.43,90.41 161.69,90.67 162.26,90.67
+3V_RTC_0 on BOTTOM (solid shape): 195.78,61.19 195.78,58.45 195.55,58.22 191.69,58.22 191.46,58.45 191.46,61.16 191.69,61.39 195.58,61.39
+3V_S2 on TOP (solid shape): 69.62,34.72 69.62,34.09 70.19,33.52 70.19,32.49 69.36,31.67 69.19,31.67 69.15,31.66 69.11,31.64 69.07,31.62 69.04,31.59 69.02,31.56 69,31.55 68.99,31.55 67.33,31.55 67.33,31.68 68.1,31.68 68.1,31.89 67.45,31.89 67.45,31.68 67.33,31.68 67.33,33.83 67.59,34.09 68.1,34.09 68.86,34.85 69.49,34.85
+3V_WLAN_P on TOP (solid shape): 183.33,59.61 183.33,58.73 183.16,58.55 182.51,58.55 182.47,58.59 182.47,59.37 182.9,59.79 183.15,59.79
+3V_WLAN_P on TOP (solid shape): 193.75,162.73 193.75,161.94 193.84,161.85 195.41,161.85 195.53,161.73 195.53,160.74 195.39,160.6 193.26,160.6 192.29,161.57 192.29,162.9 192.44,163.06 193.43,163.06
+3V_WLAN_P on TOP (solid shape): 186.84,160.87 186.84,158.14 186.82,158.12 186.56,158.12 186.26,158.42 186.26,158.9 186.2,158.96 186.2,158.97 186.14,159.09 186.02,159.16 186,159.16 185.85,159.31 185.39,159.31 185.09,159.61 185.09,160.88 185.32,161.11 186.6,161.11
+3V_WLAN_P on TOP (solid shape): 175.41,158.93 175.41,158.61 174.58,157.79 174.58,156.44 174.57,156.4 174.53,156.39 173.25,156.39 173.22,156.4 173.2,156.44 173.2,157.61 172.18,157.61 172.18,156.73 171.9,156.45 171.41,156.45 171.09,156.77 171.09,157.53 170.58,158.04 170.58,158.67 170.72,158.8 172.22,158.8 172.66,158.36 172.82,158.36 172.89,158.31 172.98,158.3 173.26,158.3 173.42,158.36 173.48,158.52 173.48,158.78 173.89,159.18 175.16,159.18
+3V_WLAN_P on TOP (solid shape): outline of 185 points within 191.03,77.9 198.14,85.9
+3V_WLAN_P on BOTTOM (solid shape): 186.85,158.84 186.85,156.08 186.85,156.07 186.85,154.5 187.28,154.07 193.04,154.07 193.17,153.94 193.17,153.43 193.02,153.28 187.15,153.28 186.35,154.08 186.35,156.09 186.35,158.83 186.45,158.93 186.77,158.93
+3V_WLAN_P on BOTTOM (solid shape): outline of 202 points within 172.59,154.58 198.32,162.86
+3V_WLAN_P on IN2 (solid shape): outline of 903 points within 190.87,78.61 196.81,162.86
+3VCARD on TOP (solid shape): 62.56,21.95 62.56,21.08 62.41,20.93 62.03,20.93 61.34,21.62 61.34,21.95 61.49,22.1 62.41,22.1
+3VCARD on TOP (solid shape): 36.73,24.31 36.73,23.93 36.73,23.93 36.73,23.42 37.36,22.78 37.36,22.37 37.17,22.19 36.41,22.19 36.4,22.17 35.08,22.17 34.8,21.9 32.87,21.9 32.73,22.04 32.73,23.32 32.95,23.55 34.69,23.55 35.71,24.56 36.47,24.56
+3VCARD on BOTTOM (solid shape): outline of 206 points within 35.23,20.37 62.76,23.42
+3VLANVCC on TOP (solid shape): 52.58,99.16 53.29,99.16 53.74,98.7 53.74,98.43 53.52,98.2 50.52,98.2 50.16,98.55 50.16,99.59 50.52,99.95 51.79,99.95
+3VLANVCC on TOP (solid shape): 73.51,85.6 73.51,85.04 73.15,84.68 71.6,84.68 71.5,84.79 71.5,85.45 71.58,85.52 72.11,85.52 72.29,85.7 73.4,85.7
+3VLANVCC on TOP (solid shape): 86.13,45.77 86.13,43.87 86,43.74 85.41,43.74 84.02,45.13 84.02,46.07 84.2,46.25 85.65,46.25
+3VLANVCC on TOP (solid shape): 68.4,82.99 68.4,82.31 68.82,81.89 68.82,81.55 68.71,81.43 67.71,81.43 67.46,81.18 67.46,80.19 67.21,79.93 66.85,79.93 66.72,80.06 66.72,83.01 66.87,83.15 68.25,83.15
+3VLANVCC on TOP (solid shape): 20.01,116.03 20.01,115.77 19.53,115.29 19.53,114.94 18.82,114.22 17.14,114.22 16.76,113.84 16.76,113.21 16.66,113.11 15.74,113.11 15.7,113.15 15.7,114.89 16.06,114.89 16.18,115.01 16.7,115.01 16.71,115.01 16.84,114.99 16.97,115.01 16.98,115.01 17.29,115.01 17.32,115.01 17.62,115.01 17.66,115.01 18.09,115.01 18.18,115.1 18.18,115.67 18.31,115.8 19.12,115.8 19.51,116.18 19.86,116.18
+3VLANVCC on TOP (solid shape): 26.67,113.48 27.65,113.48 27.92,113.21 27.92,113.2 27.95,113.19 27.96,113.15 27.96,111.43 28.09,111.3 30.43,111.3 30.68,111.05 30.68,109.88 30.41,109.61 28.95,109.61 28.87,109.65 28.85,109.73 28.85,109.75 28.61,110.14 28.17,110.02 28.1,109.87 28.1,109.71 28.1,109.68 28.08,109.66 28.04,109.61 26.6,109.61 26.37,109.85 26.35,109.88 26.35,109.91 26.36,109.93 26.36,110.9 26.24,110.9 26.2,110.91 26.19,110.95 26.19,112.95 25.68,113.46 25.04,113.46 24.53,113.97 24.53,114.35 24.79,114.61 25.55,114.61
+3VLANVCC on BOTTOM (solid shape): 54.46,97.76 54.46,97.13 53.8,96.47 53.39,96.47 51.66,98.2 51.66,98.65 52.09,99.09 53.14,99.09
+3VLANVCC on BOTTOM (solid shape): 73.04,86.89 73.07,86.82 73.04,86.75 73.02,86.22 73.55,86.19 73.62,86.21 73.69,86.19 73.74,86.15 73.81,86.11 73.92,86.01 73.94,85.91 73.87,85.84 73.59,85.57 73.7,85.2 73.73,85.13 73.7,85.05 73.61,84.96 72.64,84.96 71.42,86.18 71.42,87 71.93,87.5 72.42,87.5
+3VLANVCC on IN2 (solid shape): 85.14,44.83 85.14,44.55 84.96,44.37 83.07,44.37 82.23,45.22 82.23,46.07 82.33,46.17 83.8,46.17
+3VLANVCC on IN2 (solid shape): 18.95,121.34 18.95,116.26 20.72,114.48 25.68,114.48 26.95,113.21 26.95,111.58 26.92,111.56 25.57,111.56 25.55,111.58 25.54,111.6 25.51,111.71 25.45,111.81 25.43,111.87 25.46,111.94 25.3,112.55 24.79,112.17 24.76,112.1 24.69,112.07 22.63,112.07 22.26,111.7 17.79,111.7 16,113.49 16,115.09 16.27,115.36 16.29,115.37 16.36,115.37 16.43,115.35 16.47,115.29 17.12,115.11 16.89,115.75 16.81,115.81 16.83,115.92 17.42,116.51 17.42,121.17 17.47,121.25 17.56,121.26 17.85,121.26 18.05,121.46 18.82,121.46
+3VLANVCC on IN2 (solid shape): outline of 204 points within 66.27,80.29 73.65,85.73
+3VLANVCC_S2 on TOP (solid shape): 68.99,30.08 69,30.06 69.01,30.02 69.04,29.98 69.07,29.95 69.11,29.93 69.15,29.91 69.19,29.9 69.24,29.9 69.82,29.31 69.82,27.67 69.79,27.66 69.74,27.64 69.7,27.61 69.65,27.57 69.62,27.52 69.59,27.47 69.57,27.42 69.56,27.38 69.41,27.23 68.73,27.23 68.22,27.74 67.46,27.74 67.27,27.93 67.27,29.68 68.1,29.68 68.1,29.89 67.45,29.89 67.45,29.68 67.27,29.68 67.27,29.96 67.4,30.08
+3VLCD_CON on TOP (solid shape): outline of 253 points within 48.67,174.7 63.02,183.16
+3VLCD_CON on BOTTOM (solid shape): 62.06,181.75 62.09,181.72 62.66,181.15 62.66,181.14 62.86,180.93 63.14,180.92 63.15,180.92 63.18,180.92 63.22,180.88 63.22,179.53 62.99,179.3 60.46,179.3 58.83,180.92 58.83,182.55 59.07,182.79 61.01,182.79
+3VPCU on BOTTOM (solid shape): 56.56,52.81 56.56,51.99 56.36,51.79 55.6,51.79 54.95,51.15 54.05,51.15 54.01,51.16 54,51.2 54,51.35 54.01,51.38 54.05,51.4 54.7,51.4 54.76,51.47 54.76,51.98 54.76,51.98 54.76,52.4 55.27,52.91 56.46,52.91
+3VPCU on IN2 (solid shape): outline of 385 points within 39.59,80.82 55.01,83.62
+3VS5 on TOP (solid shape): 66.06,30.02 66.06,28.12 65.94,27.99 64.67,27.99 64.54,28.12 64.54,29.39 64.84,29.68 65.95,29.68 65.95,29.89 65.3,29.89 65.3,29.68 64.84,29.68 65.24,30.08 66,30.08
+3VS5 on TOP (solid shape): 181.25,64.82 182.7,64.82 182.95,64.57 182.95,63.35 182.78,63.17 181.8,63.17 181.54,63.44 181.01,63.44 180.99,63.44 180.97,63.46 180.89,63.53 180.8,63.58 180.79,63.58 180.08,64.29 180.08,65.25 180.16,65.33 180.74,65.33
+3VS5 on TOP (solid shape): 188.62,80.44 188.62,79.43 189.48,79.43 190.02,78.89 190.02,77.52 187.76,77.52 187.44,77.2 187.44,75.59 187.15,75.3 181.44,75.3 181,75.74 181,77.02 182.26,78.28 183.92,78.28 183.93,78.28 184.17,78.25 184.39,78.36 184.46,78.38 184.53,78.35 185.12,78.28 185.22,78.86 185.2,78.9 185.17,78.93 185.14,79 185.17,79.07 185.29,79.37 185.17,79.67 185.14,79.73 185.17,79.8 185.22,79.86 185.25,79.92 185.29,80.04 185.29,80.19 185.3,80.21 185.79,80.7 188.36,80.7
+3VS5 on TOP (solid shape): outline of 104 points within 62.63,31.49 66.9,40.23
+3VS5 on TOP (solid shape): outline of 342 points within 160.98,89.46 167.94,92.61
+3VS5 on BOTTOM (solid shape): 182.11,95.96 182.11,95.95 182.28,95.8 182.5,95.75 185,95.75 185.57,95.17 185.89,95.17 185.95,95.17 185.96,95.16 186.22,95.16 186.33,95.05 186.33,93.93 186.3,93.9 186.06,93.9 185.9,93.83 185.83,93.67 185.83,93.45 185.83,93.45 185.83,92.87 185.75,92.79 185.54,92.79 185.1,93.24 185.1,93.49 185.04,93.55 183.89,93.55 183.67,93.77 183.67,93.79 183.56,94.05 183.3,94.16 183.28,94.16 182.78,94.67 181.68,94.67 181.63,94.72 181.63,94.92 181.61,95.02 181.55,95.1 181.51,95.17 181.55,95.25 181.61,95.33 181.63,95.42 181.63,95.56 181.63,95.7 181.62,95.76 181.6,95.82 181.59,95.84 181.59,95.87 181.71,95.99 182.06,95.99
+3VS5 on BOTTOM (solid shape): outline of 693 points within 57.68,35.61 74.83,47.34
+3VS5 on BOTTOM (solid shape): outline of 914 points within 60.73,23.04 82.93,33.71
+3VS5 on IN1 (solid shape): 65.56,33.33 66.04,33.33 66.55,32.82 66.55,32.31 66.19,31.95 66.19,29.73 66.79,29.13 66.79,28.16 66.42,27.79 65.15,27.79 63.63,29.31 63.63,31.14 64.34,31.14 64.34,31.09 64.35,31.03 64.37,30.98 64.4,30.93 64.43,30.89 64.47,30.85 64.52,30.81 64.57,30.79 64.62,30.77 64.68,30.76 64.73,30.76 64.79,30.76 64.84,30.78 64.89,30.8 64.94,30.83 64.98,30.87 65.02,30.91 65.05,30.95 65.07,31 65.09,31.06 65.1,31.11 65.1,31.17 65.09,31.22 65.07,31.28 65.05,31.33 65.02,31.37 64.98,31.42 64.94,31.45 64.89,31.48 64.84,31.5 64.79,31.52 64.73,31.52 64.68,31.52 64.62,31.51 64.57,31.49 64.52,31.47 64.47,31.43 64.43,31.4 64.4,31.35 64.37,31.3 64.35,31.25 64.34,31.2 64.34,31.14 63.63,31.14 63.63,33.93 63.8,34.11 64.77,34.11
+3VS5 on SVCC (solid shape): outline of 600 points within 74.7,15.42 192.05,97.46
+3VSPI on BOTTOM (solid shape): 180.52,108.36 181.91,108.36 183.93,106.34 183.93,104.42 184.34,104.01 184.73,104.01 185.95,102.79 185.95,102.54 185.57,102.16 183.28,102.16 183.16,102.29 183.16,103.43 182.52,104.06 182.52,105.08 182.01,105.59 180.74,105.59 180.62,105.72 180.62,106.17 181.2,106.76 181.2,106.82 181.21,106.84 181.24,106.9 181.25,106.96 181.25,107.24 181.21,107.38 181.09,107.46 181.08,107.46 181.05,107.49 179.68,107.49 179.61,107.56 179.61,108.01 179.67,108.07 179.86,108.07 180.03,108.11 180.17,108.2 180.35,108.38 180.49,108.38
+3VSUS on IN2 (solid shape): 160.81,19.28 160.9,19.23 160.9,19.13 161.23,18.57 161.58,19.11 161.59,19.21 161.68,19.25 161.98,19.25 161.99,19.26 166.2,19.26 166.34,19.13 166.34,19.12 166.49,18.98 166.49,18.58 164.77,16.87 164.34,16.87 164.26,16.91 164.24,17 164.19,17.35 163.87,17.5 163.85,17.5 163.45,17.91 160.51,17.91 160.23,18.18 160.23,19.16 160.35,19.28
+3VSUS_S2 on TOP (solid shape): 68.88,40.16 68.89,40.13 68.92,40.08 68.95,40.03 68.99,39.98 69.04,39.94 69.09,39.91 69.14,39.88 69.2,39.87 69.26,39.85 69.32,39.85 69.38,39.86 69.44,39.87 69.49,39.89 69.52,39.9 69.79,39.63 69.79,38.76 69.87,38.68 69.87,37.9 69.62,37.64 67.59,37.64 67.27,37.96 67.27,39.84 68.1,39.84 68.1,40.05 67.45,40.05 67.45,39.84 67.27,39.84 67.27,40.17 67.34,40.24 68.8,40.24
+5V on TOP (solid shape): 76.1,61.39 76.1,60.63 75.84,60.38 73.43,60.38 73.18,60.63 73.18,61.14 73.68,61.65 75.84,61.65
+5V on TOP (solid shape): 22.73,92 22.73,90.32 22.99,90.07 23.8,90.07 23.9,89.97 23.9,89.54 23.85,89.48 21.39,89.48 21.23,89.64 21.23,92.02 21.31,92.1 22.63,92.1
+5V on TOP (solid shape): 145.57,10.47 145.57,9.7 145.69,9.58 147.88,9.58 148.19,9.27 148.66,9.27 148.79,9.14 148.79,8.48 148.61,8.31 144.8,8.31 144.66,8.44 144.66,9.86 144.3,10.23 144.3,10.72 144.42,10.85 145.18,10.85
+5V on TOP (solid shape): 74.32,45.75 74.32,43.37 73.16,42.22 72.9,42.22 72.67,42.29 72.44,42.22 70.89,42.22 70.64,42.47 70.64,43.92 70.13,44.42 70.13,44.81 69.7,45.24 69.7,45.62 70.1,46.03 74.05,46.03
