# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS5: length 292.9
  TOP w0.254: 186.82,30.54 187.22,30.13 U15.1 ; C499.2 193.64,27.63 U15.13
  TOP w0.305: 162.01,89.65 160.94,89.65 160.38,89.08 158.83,89.08 158.7,88.95 157.42,88.95 156.15,90.22 155.34,90.22 154.96,90.6 154.96,91.99 154.78,92.17 C307.2 ; R7469.1 171.99,75.74 171.99,73.09 171.47,72.57 169.7,72.57 169.31,72.19 169.31,69.01 171.87,66.45 CN9.7 174.24,66.45 174.79,65.9 179.79,65.9 180.34,65.35 v2(180.34,65.05)
  TOP w0.381: v2(194.59,27.61) 194.47,27.49 C499.2 ; R359.2 194.29,28.96 195.05,28.96 R357.2 ; v2(183.56,94.68) 183.5,94.68 183.49,94.69 183.05,94.69 R168.2
  TOP w0.508: R358.2 196.1,29 v2(195.6,28.5) 195.1,29 R357.2 ; R358.2 196.36,29 196.74,29.38 C786.1 ; R358.2 196.37,28.74 R362.2 R364.2 ; R259.2 180.86,75.35 182.14,76.63 ; 167.66,92.51 167.66,93.54 168.15,94.03 171.88,94.03 172.44,94.59 172.44,95 173.13,95.69 R169.2 R173.2 R626.2 175.92,95.82 178.25,95.82 178.48,95.58 181.79,95.58 v2(181.94,95.73) ; EC49.2 v2(97.43,24.31) ; 186.39,30.8 185.69,30.1 R356.2 R360.2 R361.2 R363.2 ; 186.85,31.05 187.68,31.05 188.06,31.43 188.06,32.27 188.06,32.27 v2(188.06,32.33) ; v2(57.99,44.91) 58.6,45.52 58.6,48.72 58.04,49.28 PR111.1
  IN1 w0.508: v2(194.59,27.61) 194.71,27.61 v2(195.6,28.5)
  IN2 w0.508: v2(40.41,174.8) 39.9,174.8 39.52,174.42 39.52,166.17 38.57,165.21 38.57,163.82 41.86,160.52 41.86,154.98 34.95,148.07 34.95,100.91 37.19,98.67 37.19,94.8 37.63,94.36 37.63,91.8 38.05,91.38 38.05,82.27 36.42,80.65 36.42,66.7 37.11,66.01 37.11,64.44 40.16,61.39 42.31,61.39 43.57,60.13 47.08,60.13 48.1,59.12 53.79,53.42 54.63,53.42 55.16,53.42 56.79,51.79 56.79,50.85 58.32,49.32 58.32,45.24 v2(57.99,44.91)
  BOTTOM w0.305: U25.AH10 162.34,90.04 162.79,90.49 v2(162.81,90.49)
  BOTTOM w0.381: R563.1 181.89,89.51 v2(181.91,89.48)
  BOTTOM w0.508: v2(40.41,174.8) 40.79,174.8 42.19,176.2 ; v2(188.06,32.33) 187.98,32.41 187.98,32.93 188.14,33.08 188.14,33.74 190.57,36.18 191.81,36.18 191.82,36.17 ; 191.82,36.17 194.82,36.17 195.58,35.41 195.58,33.91 195.98,33.5 196.95,33.5 197.76,32.69 197.76,29.01 197.25,28.5 v2(195.6,28.5) ; 191.82,36.17 193.44,37.8 193.44,40.15 192.77,40.82 185.06,40.82 184.05,41.83 184.05,46.96 v2(183.79,47.22) ; 42.19,176.2 42.49,176.5 46.81,176.5 49.93,179.63 ; 42.19,176.2 R7466.1 ; R502.2 183.54,100.85 184.46,99.92 186.67,99.92 189.51,97.09 v2(189.51,97)
  vias: v1(63.52,34.98) v1(186.71,77.78) v2(64.92,29.22) v2(64.92,28.59) v2(180.34,64.41) v2(185.42,93.57) v2(185.71,92.91) v5(63.9,38.15) v5(63.9,37.39) v5(63.9,36.63) v5(63.96,33.58) v5(64.33,32.94) v5(64.32,32.08) v5(64.67,38.15) v5(64.67,37.39) v5(64.67,36.63) v5(64.77,33.61) v5(64.96,32.56) v5(65.56,36.88) v5(65.7,32.56) v5(66.43,32.49) v5(79.65,24.28) v5(80.17,23.76) v5(80.3,24.63) v5(80.92,24.23) v5(80.86,23.5) v5(186.66,80.01) v5(187.42,80.01) v5(188.19,80.01)
+3VSPI: length 1.1
  BOTTOM w0.127: R491.2 179.67,107.55 v1(178.8,107.55)
+3VSUS: length 139.7
  TOP w0.381: v2(166.11,18.77) 166.11,19.18 165.67,19.62 R403.2 R401.2
  TOP w0.508: v2(70.38,35.23) 70.38,35.92 70.74,36.27 PR117.1 ; CN16.6 171.25,17.62 C577.1 171.21,17.34 169.97,16.1 166.58,16.1 165.58,16.1 164.59,17.1 ; v2(89.84,28.58) 90.3,28.58 90.5,28.78 90.5,28.78 v1(90.52,28.78) ; v2(160.53,18.95) 160.36,19.11 R415.1 ; 164.59,17.1 164.59,16.86 163.37,15.65 161.62,15.65 160.97,16.3 R412.1 155.29,16.3 154.18,15.19 147.62,15.19 146.39,13.96 132.19,13.96 129.39,11.15 124.56,11.15 124.43,11.02 110.06,11.02 109.46,11.62 107.5,11.62 96,11.62 94.77,12.85 v2(90.57,12.85) ; 164.59,17.1 v2(164.59,17.12)
  IN2 w0.508: v2(89.84,28.58) 89.99,28.42 89.99,27.25 91.97,25.27 91.97,23.68 92.53,23.12 92.53,14.53 90.85,12.85 v2(90.57,12.85)
  BOTTOM w0.508: v2(89.84,28.58) 89.99,28.73 89.99,31.24 88.26,32.97 86.23,32.97 85.11,31.85 73.12,31.85 71.96,33.02 71.96,33.66 v2(70.38,35.23)
+3VSUS_S2: length 1.2
  TOP w0.127: v1(66.57,38.53) 66.6,38.51 PC95.1
+5V: length 447.5
  TOP w0.127: v1(23.24,88.77) 23.62,89.15 VC2.1
  TOP w0.381: EC57.2 93.42,16.31 v2(93.29,16.18) ; R90.1 195.35,157.79 191.46,157.79 v2(189.18,155.5) ; C787.1 v2(34.57,54.92)
  TOP w0.508: v2(203.1,13.72) 203.1,22.66 v2(202.33,23.42) ; CN12.1 38.78,53.5 v2(38.5,53.77) ; R413.2 v2(39.39,10.85) ; CN11.8 v2(200.47,56.45) ; v2(151.79,11.94) 151.79,13.03 152.25,13.49 154.53,13.49 155.09,14.05 155.62,14.05 155.72,14.15 L42.2 ; CN11.3 v2(200.54,52.45) ; R422.2 v2(34.56,8.69)
  TOP w0.635: Q20.3 165.63,135.05 164.62,134.04 164.11,134.04 162.05,131.98 160.17,131.98 156.64,128.45 156.64,121.62 v5(156.54,121.51)
  TOP w1.016: 73.68,60.88 71.4,58.6 71.4,45.9
  IN2 w0.381: v5(191.23,91.26) 191.23,91.88 191.6,92.25 191.6,98.21 190.71,99.1 190.71,101.3 189.77,102.24 189.77,108.31 190.08,108.62 190.08,109.59 189.71,109.95 189.71,120.08 188.41,121.39 188.41,145.7 186.05,148.06 186.05,152.37 v2(189.18,155.5)
  IN2 w0.508: v2(34.57,54.92) 35.71,53.77 v2(38.5,53.77) ; v2(39.39,10.85) 37.23,8.69 v2(34.56,8.69)
  IN2 w0.762: v2(67.12,174.07) 68.21,175.16 83.62,175.16 87.23,171.55 87.23,171.02 87.23,171.01 87.23,167.05 86.98,166.8 86.98,166.8 86.27,166.09 86.27,154.73 100.51,140.49 100.51,112.62 100.89,112.24 ; v5(156.54,121.51) 154.96,119.94 139.98,119.94 v5(139.22,119.18) 138.4,118.36 133.41,118.36 133.31,118.26 120.1,118.26 116.89,115.05 106.39,115.05 105.18,113.84 105.18,112.83 105.16,112.74 105.16,111.43 104.65,110.92 103.83,110.92 102.51,112.24 100.89,112.24 ; 100.89,112.24 100.51,111.86 100.51,109.04 78.64,87.17 v5(78.64,85.4) v2(78.64,84.48)
  BOTTOM w0.508: v2(34.56,8.69) 34.16,8.28 33.07,8.28 30.12,11.23 30.12,28.88 v2(31.14,29.9) ; v2(186.19,25.04) 186.24,25.04 186.29,25 186.81,25 187.85,26.04 189.46,26.04 190.02,25.48 199.2,25.48 199.94,24.74 200.73,24.74 202.03,23.44 202.31,23.44 v2(202.33,23.42) ; v2(22.38,81.97) 22.88,81.97 23.14,82.22 25.68,82.22 27.07,80.82 27.07,75.62 28.09,74.6 28.09,71.04 32.92,66.22 32.92,62.54 33.55,61.9 33.55,55.3 33.93,54.92 v2(34.57,54.92) ; FAN1.1 138.67,119.9 137.95,119.18 C706.1 139.12,115.72 C704.2 v5(139.22,119.18) ; v2(203.1,13.72) 201.38,13.72 L47.2
  BOTTOM w0.762: v5(78.64,85.4) v2(78.64,84.48) 78.64,80.19 76.63,78.18 76.63,76 77.49,75.13 78.1,75.13 79.7,73.53 79.7,64.64 78.51,63.45
  vias: v2(21.79,89.76) v2(22.45,89.79) v2(56.41,29.77) v2(56.41,29.13) v2(75.08,61.27) v2(75.72,61.27) v2(148.08,9.32) v2(185.2,24.25) v2(185.67,24.67) v2(186.55,25.63) v2(199.06,45.01) v2(199.06,44.37) v2(199.06,43.1) v2(199.06,42.34) v5(70.15,44.63) v5(70.79,45.01) v5(70.79,44.25) v5(71.58,44.25) v5(72.24,43.51) v5(72.26,42.77) v5(73.05,42.7) v5(73.43,24.31) v5(73.43,23.55) v5(75.59,26.44) v5(76.33,26.31) v5(76.99,26.67) v5(77.7,26.31) v5(78.41,26.7) v5(191.92,90.91) v5(192.53,91.47) v5(192.68,90.7) v5(192.97,79.46) v5(193.08,80.19) v5(193.7,79.17) v5(193.83,79.93)
+5V_AMP: length 9.7
  BOTTOM w0.127: v2(195.25,14.15) 194.99,13.89 v1(194.56,13.89)
  BOTTOM w0.254: C802.2 191.79,18.67 191.79,18.46 192.06,18.2 U28.20 ; U28.12 195.09,14.31 v2(195.25,14.15)
  BOTTOM w0.508: v2(190.17,20.04) 190.17,19.83 190.02,19.68 C801.2 C802.2 ; R611.2 R612.2 199.29,15.05 v2(199.29,14.66) 200.18,13.77 L47.1
+5V_AVDD: length 36.2
  TOP w0.254: C589.1 188.64,7.38 188.64,8.71 v1(189.25,9.32) 189.34,9.4 189.34,10.89 188.72,11.51 U20.27
  TOP w0.305: 188.58,18.47 187.49,18.47 187.02,17.99 187.02,17.99 186.78,17.75 186.78,17.75 186.68,17.64 U20.38
  TOP w0.508: C589.1 189.13,5.41 C596.1 188.44,5.79 188.44,5.99 v2(188.06,6.38) ; R432.1 178.47,5.38 v2(178.97,4.88)
  IN1 w0.508: v2(188.06,6.38) 188.44,6.76 188.44,8.41 189.33,9.3 189.33,11.18 190.85,12.7 190.85,14.3 189.38,15.77 189.38,17.07 v2(188.87,17.58)
  IN2 w0.508: v2(178.97,4.88) 179.6,5.51 187.73,5.51 188.06,5.84 v2(188.06,6.38)
+5V_CAM: length 37.1
  TOP w0.508: v2(55.38,163.02) PQ43.4 57.16,164.15 PC252.1 57.63,162.88 PC253.1 ; PR237.1 47.2,167.82 v1(47.5,168.12) v2(48.51,169.14)
  IN1 w1.016: v2(48.51,169.14) 48.51,168.17 53.67,163.02 v2(55.38,163.02)
  BOTTOM w0.94: L59.1 62.06,173.17
  BOTTOM w1.016: v2(48.51,169.14) 48.51,170.59 49.81,171.88 53.44,171.88 55.29,170.03 57.73,170.03 60.88,173.17 62.06,173.17
+5V_CAM_C:
  vias: v1(65.71,178.13) v2(66.47,178.74) v2(67.23,178.74)
+5V_CAM_ONG: length 9.2
  TOP w0.127: PQ41.2 45.13,161.95 PQ42.3 45.25,160.1 PR245.1 46.17,159.45 PR246.2 v1(47.75,159.45) 48.48,159.45 PQ44.2
+5V_DVDD: length 7.1
  TOP w0.127: v2(181.92,24.21) 181.94,24.21 182.45,23.71
  TOP w0.305: C556.1 183.21,18.6 183.21,17.58 183.18,17.55 U20.45 ; 183.79,18.97 185.95,18.97 186.18,18.75 U20.39
+5V_HDMIC: length 3.5
  TOP w0.127: C313.1 15.38,91.1 v1(15.01,90.73)
  TOP w0.508: D3.2 v2(20.88,88.95) ; D5.2 v2(20.88,86.67)
  vias: v2(16.79,90.35) v2(17.42,90.35)
+5V_ODD:
  vias: v1(192.68,94.41) v5(193.52,95.17) v5(193.52,94.41) v5(193.52,93.65)
+5V_S2: length 1.7
  TOP w0.127: v1(68.22,46.15) 68.22,45.89 PC77.1
+5V_USBP0:
  vias: v1(19.84,51.36) v2(17.55,51.61) v2(17.8,50.98) v2(18.18,51.61) v2(18.44,50.98) v2(18.82,51.61) v2(19.07,50.98)
+5V_USBP1:
  vias: v1(21.61,56.69) v2(17.93,61.47) v2(24.59,76.73) v2(25.32,77.34) v2(25.27,76.71) v2(25.27,76.07) v5(17.82,55.24) v5(19.6,56.67) v5(19.61,55.25)
+5VPCU: length 197.4
  TOP w0.508: R381.1 141.25,20.81 140.74,20.3 126.33,20.3 v1(125.78,20.85) 125.74,20.89 125.74,21.4 124.01,23.13 124.01,24.72 123.43,25.3 122.17,25.3 121.38,26.09 111.54,26.09 108.36,29.26 v2(108.36,31.53) ; PR69.2 41.12,93.55 v2(40.54,92.96) 40.11,92.96 EC23.1 ; PR68.2 45.19,92.91 v2(45.21,92.89)
  IN1 w0.508: v2(34.52,93.66) 38.71,93.66 39.4,92.96 v2(40.54,92.96) 45.14,92.96 v2(45.21,92.89)
  IN2 w0.508: v2(108.36,31.53) 106.41,31.53 105.94,32 105.94,32.03 102.61,35.36 100.96,35.36 98.19,38.13 96.19,38.13 92.91,41.4 91.81,41.4 90.78,42.44 90.78,45.03 90.07,45.75 90.07,46.86 90.5,47.3 v2(90.6,47.3) ; v2(34.52,93.66) 33.36,92.5 33.36,86.42 33.9,85.89 33.9,83.43 33.18,82.72 33.18,75.1 33.39,74.89 33.39,65.37 33.78,64.97 34.67,64.97 35.2,64.44 35.2,63.55 35.46,63.3 37.36,63.3 40.02,60.63 42.06,60.63 43.19,59.5 46.82,59.5 53.53,52.79 54.9,52.79 56.16,51.52 56.16,50.5 57.55,49.1 57.55,45.92 57.22,45.59 v2(57.22,44.55) 57.15,44.48 47.04,44.48 v2(46.51,45.01)
  BOTTOM w0.508: v2(57.22,44.55) 57.22,45.16 58.64,46.57 58.64,47.14 59.05,47.56 59.05,47.58 59.33,47.85 63.27,47.85 64.64,46.48 68.25,46.48 68.78,45.95 71.32,45.95 73.2,44.07 87.27,44.07 90.5,47.3 v2(90.6,47.3)
+5VS5: length 323.7
  TOP w0.127: PC110.1 63.78,30.66 65.07,30.66 65.19,30.79 PU8.4
  TOP w0.178: PU5.4 PC85.1
  TOP w0.381: PC85.1 63.66,41.12 v2(63.26,41.52)
  TOP w0.508: v2(99.46,78.54) 99.46,78.03 99.11,77.67 PR97.2 101.75,74.5 v2(101.75,74.35) ; v2(64.72,31.14) 64.02,31.14 PC110.1 ; v2(106.83,66.35) 105.56,65.08 105.56,62.41 100.48,57.33 93.88,57.33 91.84,55.3 91.84,47.42 v2(90.7,46.28) ; v2(107.57,32.79) 107.57,33.1 108.18,33.71 R383.1 ; v2(193.79,70.43) 194.69,70.43 197.39,67.73 PR102.1 197.52,67.16 198.4,67.16 199.16,66.4 v2(199.16,61.49)
  TOP w0.762: v2(87.4,164.26) 80.29,164.26 79.53,165.02 v2(78.51,165.02)
  IN1 w0.889: 187.58,23.65 187.58,25.44 188.68,26.54 191.72,26.54 194.33,29.16
  IN2 w0.508: 202.84,33.5 202.84,52.41 199.83,55.42 199.83,61.1 199.44,61.49 v2(199.16,61.49)
  IN2 w0.762: v2(90.07,86) v2(90.07,86.79) 90.27,87 91.02,87 96.85,92.83 v2(96.85,94.36) v2(96.85,95.17) ; v2(106.45,123.27) v2(106.45,124.31) 106.45,132.84 101.98,137.31 101.98,140.28 87.4,154.86 v2(87.4,164.26)
  IN2 w1.524: 87.45,10.74 87.45,9.53 89.18,7.8 116.77,7.8
  BOTTOM w0.381: R596.1 R597.1 18.3,72.2 18.06,72.44 v2(18.06,75.36) ; v2(26.19,72.19) 26.05,72.05 R595.2
  BOTTOM w0.508: v5(65.86,43.43) 69.58,43.43 72.04,40.97 77.01,40.97 79.27,43.23 87.65,43.23 v2(90.7,46.28) ; v2(101.75,74.35) 106.83,69.27 v2(106.83,66.35) ; v2(107.57,32.79) 107.54,32.82 107.28,32.82 105.38,34.71 105.38,35.89 v2(105.18,36.09)
  BOTTOM w0.762: v2(96.85,94.36) v2(96.85,95.17) 96.85,103.1 100.37,106.62 100.37,113.35 106.45,119.43 v2(106.45,123.27) v2(106.45,124.31) ; v2(90.07,86.79) v2(90.07,86) 90.06,86.01 88.67,84.62 88.67,80.57 90.7,78.54 v2(99.46,78.54) ; v2(78.51,165.02) 78.51,164.52 75.72,161.72 62.13,161.72 59.79,164.06 57.63,164.06 v2(56.54,165.15)
  vias: v1(116.1,17.45) v2(20.55,76.02) v2(20.93,75.51) v2(21.18,76.12) v2(25.4,79.07) v2(25.86,78.61) v2(26.31,78.16) v2(86.43,13.77) v2(86.61,13.11) v2(87.07,13.77) v2(87.31,13.1) v2(87.7,13.7) v2(87.96,13.08) v2(115.85,15.16) v2(116.48,15.16) v2(119.23,5.66) v2(119.99,5.66) v2(120.75,5.66) v2(121.51,5.72) v2(122.27,5.72) v2(123.04,5.72) v2(192.43,32.06) v2(192.94,31.65) v2(193.11,32.26) v2(199.67,33.58) v2(199.67,32.94) v2(199.67,32.31) v2(200.19,21.13) v2(200.19,20.5) v2(200.3,32.82) v2(200.84,21.13) v2(200.84,20.5) v2(200.78,19.87) v5(29.61,45.68) v5(29.72,46.43) v5(29.9,44.97) v5(30.33,46.96) v5(30.4,45.69) v5(30.64,44.97) v5(30.76,46.36) v5(64.2,42.59) v5(64.34,43.31) v5(64.67,41.84) v5(64.94,42.61) v5(65.07,43.34) v5(65.66,42.72)
+5VS5_S:
  vias: v1(29.39,41.33)
+AVCC: length 14.3
  TOP w0.254: U14.7 188.17,37.31 188.34,37.14 C458.2
  TOP w0.305: C458.2 188.32,35.99 187.69,36.63 v2(187.56,36.63)
  TOP w0.508: 181.63,34.9 C473.2 181.63,33.99 183.17,32.45 183.86,32.45 v2(184.01,32.31)
  BOTTOM w0.508: R7470.2 184.42,31.89 v2(184.01,32.31) 184,32.31 184,32.72 v1(184.94,33.66) 185.22,33.66 186.1,34.54 186.1,35.17 v2(187.56,36.63)
+V1.05A_AOSCSUS: length 3.1
  TOP w0.127: v1(162.85,96.18) C291.2
  TOP w0.381: v2(163.51,93.93) 163.51,93.99 162.85,94.66 C291.2
  BOTTOM w0.254: U25.AB8 163.33,93.75 v2(163.51,93.93)
+V1.05A_SUS_PCH: length 3.4
  TOP w0.127: TP8.1 162.81,93.78 163.08,93.78 163.55,93.31 v2(163.55,93)
  BOTTOM w0.254: U25.AD10 U25.AD8 163.33,92.78 v2(163.55,93)
+V1.05A_USB2SUS: length 2.6
  TOP w0.127: TP9.1 159.69,90.51 159.69,90 159.98,89.71 v2(160.24,89.71)
  BOTTOM w0.127: U25.AH13 160.57,90.04 v2(160.24,89.71)
+V1.05A_VCCUSB3SUS: length 1.5
  TOP w0.127: v2(161.05,100.62) 161.05,100.14 TP7.1
  BOTTOM w0.254: U25.J13 160.72,100.29 v2(161.05,100.62)
+V1.05S_ASATA3PLL: length 17.3
  BOTTOM w0.254: 162.23,111.58 162.23,107.35 161.11,106.23 161.11,105.83 U25.A12 161.22,105.1 U25.B11
  BOTTOM w0.508: 162.23,111.58 163.32,112.67 v1(163.32,113.21) 163.34,113.22 C710.2 163.17,114.39 163.17,115.45 163.98,116.26 L45.2 C700.2 C699.2 161.44,116.13 162.2,115.37 R485.1
+V1.05S_AUSB3PLL: length 34.6
  TOP w0.508: v2(152.07,106.31) 152.76,106.31 152.93,106.48 154.46,106.48 157.19,109.21 157.19,109.21 v1(158.14,110.16) 158.14,110.16 158.14,112.56 R150.2 158.65,112.56 159.01,112.92 159.01,113.93 v2(159.18,114.1)
  BOTTOM w0.203: v2(152.07,106.31) 152,106.23 152,105.95 151.72,105.66 151.72,105.35 152.07,105 U25.B27
  BOTTOM w0.254: 159.04,108.12 158.79,107.87 158.15,107.87 157.33,107.05 157.33,106.53 156.85,106.06 156.85,105.06 U25.B18
  BOTTOM w0.508: L44.2 163.98,120.42 162.71,119.15 C695.2 C694.2 161.09,119.08 160.68,118.67 160.68,115.9 160.17,115.39 C708.2 159.92,115.12 159.54,114.74 159.54,114.43 159.21,114.1 v2(159.18,114.1) 159.04,113.96 159.04,113.4 159.4,113.04 159.4,108.48 159.04,108.12
+V1.05S_AXCK_DCB: length 24
  TOP w0.508: v2(157.85,97.71) 157.85,97.16 158.35,96.65 C289.1 158.55,96.31 158.74,96.13 v2(158.93,95.93) ; L16.1 143.15,94.89 C299.1 C300.1 146.35,95.3 151.53,95.3 v1(151.66,95.17) 151.68,95.17 v2(152.38,94.47)
  IN1 w0.508: v2(158.93,95.93) 158.25,95.25 155.75,95.25 155.1,94.6 152.5,94.6 v2(152.38,94.47)
  BOTTOM w0.305: U25.J18 157.69,100.29 U25.K19 157.22,98.34 v2(157.85,97.71)
+V1.05S_AXCK_LCPLL: length 20.8
  TOP w0.381: v2(158.4,114.12) 158.05,114.48 v1(157.38,114.48) 156.74,113.84 R149.1
  BOTTOM w0.254: U25.A20 156.39,105.88 156.5,105.99 156.5,106.24 156.97,106.71 156.97,107.2 158.21,108.43 158.4,108.43
  BOTTOM w0.508: 158.4,108.43 158.76,108.79 158.76,112.78 158.4,113.14 v2(158.4,114.12) 158.27,114.25 C707.1 158.27,114.87 158.27,115.49 157.5,116.25 C696.1 C697.1 159.54,117.63 159.89,117.27 L46.1
+V3.3DX_1.5DX_ADO: length 7.6
  TOP w0.381: R179.1 159.21,92.53 158.83,92.91 158.83,93.55 159.15,93.87 159.16,93.87 159.54,94.25 R171.1 ; R179.1 160.52,92.53 C308.1 ; R179.1 159.27,92.27 159.27,89.63 v3(159.29,89.61)
  BOTTOM w0.305: U25.AH14 159.72,90.04 159.29,89.61 v3(159.29,89.61)
+VCC_CORE: length 5.7
  BOTTOM w0.254: U25.G57 133.51,102.06 U25.F56 ; 133.65,91.14 133.45,90.93 U25.AG57 ; U25.W57 133.01,94.68 133.54,94.68 133.74,94.88 ; U25.AB57 133.38,93.53 133.67,93.82 ; U25.F59 131.89,102.13 v2(131.57,102.44) ; v2(133.92,102.98) 133.85,102.91 U25.E57
  BOTTOM w0.381: R501.2 121.07,102.39 v2(120.55,102.39)
  vias: v1(124.1,102.54) v1(137.82,110.03) v2(111.78,101.55) v2(112.37,101.98) v2(113.05,104.57) v2(113.05,103.94) v2(113.05,103.3) v2(113.05,102.67) v2(113.13,101.96) v2(134.11,100.23) v2(134.21,98.93) v2(134.75,92.05) v2(135.44,100.89) v2(135.63,92.05) v2(135.71,97.51) v2(135.82,101.46) v2(136.33,100.95) v2(136.52,92.05) v2(137.41,92.05) v2(138.2,92.05) v2(138.61,113.21) v2(138.64,101.57) v2(138.95,102.95) v2(139.24,113.21) v2(139.36,101.5) v2(139.9,113.21) v2(140.43,97.49) v2(140.49,100.25) v2(140.49,99.62) v2(140.61,113.23) v2(140.98,101.57) v2(141.46,102.96) v2(141.61,101.57) v2(143.52,101.57) v2(143.96,102.96) v2(144.15,101.57) v2(144.88,96.11) v2(145.69,96.11) v2(146.2,101.83) v2(146.48,102.96) v2(146.63,96.09) v2(147.25,100.89) v2(147.62,100.23) v2(147.62,99.59) v2(147.65,96.09) v2(147.7,97.49) v2(148.02,100.87) v2(148.6,101.57) v2(148.61,96.09) v2(148.96,102.96) v2(149.03,100.87) v2(149.23,101.57) v2(149.71,96.09) v2(151.31,101.4) v2(151.42,102.96) v2(151.95,101.4) v2(153.17,101.44) v2(153.78,102.95) v2(153.81,101.44) v5(113,109.73) v5(113,108.99) v5(113,108.26) v5(113,107.44) v5(113.66,110.11) v5(113.66,109.35) v5(113.66,108.59) v5(113.66,107.8) v5(113.82,106.67) v5(113.82,105.2) v5(113.82,104.43) v5(113.82,103.68) v5(113.82,102.91) v5(113.82,102.17) v5(114.3,109.73) v5(114.3,108.97) v5(114.3,108.2) v5(114.3,107.37) v5(114.58,106.67) v5(114.58,105.2) v5(114.58,104.43) v5(114.58,103.68) v5(114.58,102.91) v5(114.58,102.17) v5(114.96,110.08) v5(114.96,109.35) v5(115.31,102.91) v5(115.31,102.12) v5(115.7,110.08) v5(115.7,109.35) v5(116.05,102.1) v5(116.08,102.91) v5(116.43,110.08) v5(116.43,109.35) v5(116.81,102.83) v5(117.17,110.08) v5(117.17,109.35) v5(117.88,109.86) v5(117.88,109.09) v5(125.17,106.24) v5(125.91,106.24) v5(126.05,106.98) v5(126.66,106.24) v5(126.79,106.97) v5(127.4,106.25)
+VCC_TS: length 34.2
  TOP w0.508: v2(51.2,167.82) 49.3,169.73 49.3,173.74 v1(45.57,177.47) 45.57,178.89
  BOTTOM w0.508: v2(69.34,174.14) 69.28,174.14 67.35,172.21 66.29,172.21 64.37,170.29 63.15,170.29 63.14,170.28 59.64,170.28 57.18,167.82 v2(51.2,167.82)
  vias: v2(44.85,179.88) v2(45.49,179.88)
+VCCIO_OUT: length 50
  TOP w0.381: v2(128.93,108.89) 130.43,110.39 C249.1
  IN1 w0.381: v2(166.73,112.83) 162.42,112.83 161.15,111.56 144.31,111.56 143.47,110.72 130.76,110.72 v2(128.93,108.89)
  BOTTOM w0.381: v2(128.93,108.89) 130.71,107.11 130.99,107.11 132.01,106.08 U25.A59 ; R487.2 166.66,112.91 v2(166.73,112.83)
+VCCIOA_OUT: length 3.9
  TOP w0.305: R165.1 155.99,100.03 156.67,100.71 156.67,102.46 v3(156.21,102.92)
  BOTTOM w0.254: U25.E20 156.23,102.9 v3(156.21,102.92)
+VCCRTCEXT: length 2.1
  TOP w0.254: C311.1 162.9,92.96 163.57,92.29 v2(163.57,92.06)
  BOTTOM w0.254: v2(163.57,92.06) 163.61,91.92 U25.AE7
+VIN: length 139.2
  TOP w0.381: v2(173.12,132.77) 173.12,132.76 R303.2 172.35,132.75 PR52.1 ; v2(177.95,131.12) 177.82,130.99 177.82,129.77 177.44,129.39 177.44,128.7 176.44,127.69 175.91,127.69 175.13,126.92 PR57.1 ; PR65.1 35.19,95.02 34.2,95.02 C290.2 34.16,95.17 34.69,95.7 v2(34.69,96.57) ; PR66.1 39.64,96.32 v2(39.52,96.32)
  TOP w0.508: PR246.1 47.32,160.25 48.74,161.67 48.74,164.26 49.41,164.93 PR247.1 50.09,165.58 52.78,168.28 53.74,168.28 v2(56.95,171.49)
  IN1 w0.508: v2(54.89,96.95) 51.2,96.95 50.7,97.46 41.68,97.46 40.54,96.32 v2(39.52,96.32) 38.63,97.21 35.33,97.21 v2(34.69,96.57)
  BOTTOM w0.508: v2(62.2,174.83) 59.82,174.83 56.95,171.97 v2(56.95,171.49) ; v2(54.89,96.95) 55.27,96.95 56.08,96.14 79.96,96.14
  BOTTOM w1.016: 199.85,63.14 199.85,68.39 198.34,69.9 197.89,69.9 195.61,72.17 195.61,77.34 194.77,78.18 192.52,78.18 191.7,78.99 191.7,80 191.59,80.11 191.59,80.26 190.64,81.22 186.3,81.22 183.15,84.36 183.15,88.72 185.11,90.67 185.11,90.67 185.69,91.26 185.98,91.26 186.87,91.63 188.62,93.37 188.62,94.79 190.4,96.57 190.4,99.62 190.6,99.82 190.6,104.39 191.29,105.08
  vias: v1(102.79,184.2) v2(63.47,178.66) v2(63.63,179.3) v2(64.23,179.55) v2(74.37,176.78) v2(74.93,176.45) v2(74.95,177.11) v2(93.11,174.55) v2(93.27,173.18) v2(93.36,173.84) v2(93.9,173.15) v2(195.07,51.18) v2(195.08,50.52) v2(199.16,60.86) v2(199.16,60.22) v5(100.28,182.91) v5(100.27,182.16) v5(100.97,183.19) v5(100.96,182.44)
+VIN_1.05V:
  vias: v1(194.71,62.03) v5(193.67,65.43)
+VIN_3VS5:
  vias: v1(50.44,54.41)
+VIN_5VS5:
  vias: v2(44.09,52.5)
+VIN_DDR: length 27.5
  TOP w0.381: v2(100.91,36.5) 100.61,36.2 PR131.2
  BOTTOM w0.508: PQ32.5 93.05,51.8 91.34,50.09 91.34,44.37 v1(90.45,43.49) 90.45,42.34 91.39,41.4 94.71,41.4 95.02,41.71 98.7,41.71 99.72,40.69 99.72,37.69 v2(100.91,36.5)
+VIN_VCC_CORE:
  vias: v1(99.46,89.46) v5(101.88,89.66) v5(101.88,88.9) v5(102.64,89.66) v5(102.64,88.9) v5(103.4,89.66) v5(103.4,88.9)
AGND: length 39.9
  TOP w0.254: v2(189,14.78) 188.95,14.78 188.68,14.51 U20.33 ; U21.18 159.54,7.47 v2(159.56,7.44) ; v2(152.12,7.9) 152.65,8.43 R423.2
  TOP w0.305: v2(188.16,9.7) 188.49,9.7 188.95,10.17 188.95,10.72 188.66,11.01 U20.26 ; v2(198.02,17.96) 198.22,17.75 CN14.6 ; v2(198.65,14.66) 198.65,15.02 198.88,15.25 CN14.1 ; CN14.4 198.34,16.75 198.14,16.94 197.25,16.94 ; v2(165.53,5.82) 165.46,5.82 R426.2
  TOP w0.381: EC87.1 v2(151.15,6.02) ; EC92.1 v2(151.15,7.04) ; R624.2 192.56,13.63 v2(192.56,14.07) 192.01,14.07 R625.2 ; EC91.1 v2(151.15,8.05)
  TOP w0.508: EC89.1 EC88.1 170.08,5.76 v2(169.71,5.76) ; R434.1 182.13,6.16 C588.2 ; v2(150.87,11.94) 150.87,11.96 150.85,11.99 150.85,13.36 151.79,14.3 154.26,14.3 155,15.05 C599.2 C598.2 ; EC69.1 v2(179.86,8.81) ; C589.2 189.13,8 v2(189.46,8.33) ; v2(168.17,5.56) 168.17,5.86 EC90.1 ; v2(162.46,6.27) 162.46,6.58 161.99,7.04 R605.2
  BOTTOM w0.381: 193.39,20.75 193.66,20.48 193.94,20.48 R623.2 ; 193.39,20.75 v2(193.39,20.88) ; 193.39,20.75 193.13,20.49 R622.2 ; v2(199.79,12.62) EC82.1
  BOTTOM w0.508: C806.1 198.66,14.65 v2(198.65,14.66) ; v2(151.15,8.05) 150.39,8.81 150.39,10.29 150.87,10.77 v2(150.87,11.94) ; EC80.1 198.13,18.08 v2(198.02,17.96)
  vias: v1(184.17,8.31) v1(189.38,15.52) v2(152.04,3.48) v2(154.58,3.48) v2(157.12,3.48) v2(159.66,3.48) v2(162.2,3.48) v2(164.74,3.48) v2(167.28,3.48) v2(169.82,3.48) v2(172.36,3.48) v2(174.9,3.48) v2(176.68,3.35) v2(177.19,6.78) v2(179.22,3.35) v2(179.98,4.88) v2(181.76,3.35) v2(183.79,6.78) v2(183.79,6.15) v2(184.3,3.35) v2(185.82,6.78) v2(186.74,6.78) v2(186.84,3.35) v2(187.32,6.15) v2(189.38,3.35) v2(189.51,20.07) v2(190.65,18.39) v2(190.8,8.56) v2(190.83,7.67) v2(190.88,4.83) v2(190.9,3.35) v2(191.16,14.91) v2(194.36,12.75)
DV33_18: length 2.4
  TOP w0.203: 59.36,19.25 59.4,19.21 U19.18
  TOP w0.508: C551.1 58.11,19.61 58.47,19.25 59.36,19.25
GND: length 1236.8
  TOP w0.127: v2(57.17,23.16) 57.17,23.34 56.77,23.75 55.95,23.75 55.45,23.24 v2(55.45,22.58) 55.45,19.78 55.82,19.41 v2(56.51,19.41) ; v2(58.8,19.89) 58.75,19.94 58.75,19.95 58.55,20.14 57.88,20.14 57.35,19.61 C551.2 ; v2(58.88,17.02) v2(55.5,17.02) 55.5,16 v2(55.6,15.9) ; v2(59.84,20.27) 59.54,20.27 58.7,21.11 58.09,21.11 57.61,21.58 57.61,22.03 57.17,22.47 C538.2
  TOP w0.178: PU8.11 v2(66.7,30.79) ; v2(37.98,68.13) 37.59,67.73 U11.27 ; PU5.11 v2(66.7,40.95)
  TOP w0.203: 100.28,40.18 100.17,40.08 PU7.14 ; U11.104 48,80.9 v2(48.08,80.98) ; U11.49 44.8,63.01 v2(44.7,62.92) ; U9.13 70.4,79.61 v2(70.61,79.4) ; v2(51.26,75.92) 51.47,76.13 U11.91 ; U9.7 68.8,83.95 68.93,84.08 v2(68.93,84.18) ; U18.11 78.52,18.6 78.69,18.44 v2(78.69,18.11) ; v2(93.88,88.19) 93.62,87.94 PU3.11 ; Q3.1 194.6,158.54 194.69,158.64 194.69,158.7 194.98,158.98 195.02,158.98 v2(195.18,159.13) ; U11.1 35.48,78.13 v2(35.3,78.31) ; v2(70.43,84.18) 70.43,84.05 70,83.62 U9.4 ; Q34.4 167.78,7.52 v2(167.9,7.39)
  TOP w0.254: C438.2 C433.2 30.35,40.69 v2(30.12,40.92) ; CN14.24 200,26.75 200.18,26.93 v2(200.18,27.23) 200.18,27.86 199.79,28.25 CN14.27 ; ODD15.18 193.36,90.05 193.65,89.76 v2(193.65,89.61) 193.59,89.55 ODD15.17 ; U12.7 85.6,70.83 v2(85.6,71.19) ; v2(72.74,65.38) 72.56,65.56 CN8.43 ; CN9.10 174.13,64.95 v2(174.19,64.89) ; v2(174.72,63.91) 174.68,63.95 CN9.12 173.11,63.93 172.36,63.93 172.08,63.65 172.08,63.17 172.3,62.95 CN9.14 ; v2(174.19,65.74) 173.97,65.95 CN9.8 ; U15.29 190.27,27.63 U15.10 ; v2(69.21,74.17) 69.21,74.11 69.56,73.77 CN8.24 ; v2(67.18,70.56) 66.56,71.18 CN8.30 ; C262.1 22.55,108.46 v2(22.73,108.28) ; Y2.4 25.47,109.58 v2(25.47,109.58) ; v2(75.92,177.14) 76.9,178.12 PQ35.1 ; CN8.46 74.06,65.76 73.81,65.51 v2(73.81,65.38) ; v2(75.18,65.38) 75.56,65.75 CN8.49 ; PQ17.1 v2(42.17,92.2) ; U13.5 187.38,55.41 v2(187.32,55.35) ; v2(190.9,32.06) 190.9,31.95 190.27,31.31 U15.21 ; v2(71.19,65.38) 71.06,65.51 CN8.40 ; C291.1 162.08,95.18 162.08,95.81 v2(161.95,95.94) ; ODD15.7 v2(193.98,84.55) ; PR20.1 82.75,176.02 v2(83.21,176.48) 83.21,177.09 PQ34.1 ; CN14.21 200.08,25.25 v2(200.2,25.37) ; PC9.2 95.02,184.62 95.02,183.27 v2(94.97,183.22) 94.73,183.22 PC13.2 ; v2(24.59,110.69) 24.6,110.69 C261.1 ; v2(200.2,29.26) 200.2,29.41 199.86,29.75 CN14.30 ; PR213.2 82.08,181.27 ; 82.08,181.27 PR215.1 ; 82.08,181.27 82.59,181.78 82.76,181.78 v2(83.03,182.05) ; PC239.1 94,177.19 93.32,177.87 v2(93.32,178.11) ; Q34.1 169.08,10.04 169.49,9.63 v2(169.54,9.63) ; v2(192.38,39.33) 192.07,39.02 U14.13 ; U14.19 190.12,42.49 ; CN8.31 66.56,65.72 66.91,65.38 v2(67.67,65.38) 68.06,65.77 CN8.34 ; v2(91.64,177.9) 91.46,178.09 PU1.14 ; v2(36.55,92.2) 36.71,92.37 PQ16.1 ; CN8.27 68.06,71.38 68.42,71.02 v2(68.48,71.02) ; v2(164.11,20.27) 164.11,20.36 C561.1 ; v2(194.77,81.43) 194.65,81.55 ODD15.1 ; CN8.60 81.06,66.15 81.13,66.08 v2(81.66,66.08) ; PC232.2 85.92,179.86 85.62,180.16 85.6,180.16 v2(85.55,180.21) 85.55,180.69 PC233.2 ; R420.1 170.66,13.17 170.66,13.67 170.48,13.84 v2(170.48,13.87) ; CN8.6 78.56,71.35 78.31,71.09 v2(75.68,71.09) 75.56,71.21 CN8.12 ; CN8.37 69.56,65.75 69.21,65.41 v2(69.21,65.32) ; v2(78.89,65.2) 78.56,65.53 CN8.55 ; ODD15.4 193.54,83.05 v2(193.93,83.44) ; CN8.15 74.06,73.77 73.66,74.17 v2(73.53,74.17) ; PR71.1 92.11,88.87 v2(91.72,89.26) ; CN8.21 v2(71.06,71.04) ; CN8.18 v2(72.56,71.1) ; PC237.2 87.68,174.86 v2(87.63,174.9) 87.63,174.96 88.03,175.36 PR18.2
  TOP w0.279: Q3.4 191.28,159.84 191.02,160.11 v2(191.02,160.36) ; U18.18 82.33,18.6 v2(82.32,18.59) ; U18.25 84.72,23.15 v2(84.73,23.16) ; U18.4 v2(76.35,23.15)
  TOP w0.305: C499.1 193.56,26.71 v2(193.19,26.34) ; CN2.36 55.35,178.33 54.94,178.74 v2(54.84,178.74) ; CN2.16 65.35,178.56 65.13,178.77 64.63,178.77 v2(64.52,178.66) 64.85,178.34 CN2.17 ; v2(53.34,178.74) 53.49,178.74 53.85,178.38 CN2.39 ; U10.14 23.51,75.19 23.87,74.83 ; v2(57.62,178.74) 57.94,178.74 58.35,178.33 CN2.30 ; CN2.1 v2(72.85,179.12) ; CN14.8 198.04,18.75 v2(197.81,18.97) ; 175.54,73.97 175.54,74.04 176.16,74.67 C360.1 ; R193.2 161.22,88.73 v2(161.22,88.23) ; CN2.7 v2(69.85,178.74) ; U8021.21 v2(62.89,165.01) ; v2(200.68,37.63) 200.3,37.25 HD17.1 ; CN2.4 v2(71.35,179.12) ; v2(56.98,178.74) 56.85,178.61 CN2.33 ; CN2.24 v2(61.35,178.74) ; C548.2 184.88,21.42 185.85,21.42 186.33,21.9 U17.2 ; v2(200.68,40.25) HD17.7 ; v2(200.7,38.75) HD17.4
  TOP w0.356: v2(152.07,45.47) 152.06,45.47 151.33,45.47 150.65,46.15 C419.2 ; C414.2 142.14,46.02 142.74,45.42 v2(142.9,45.42) 143.06,45.42 143.66,46.02 C415.2 ; C412.2 136.04,45.03 v2(135.97,44.96)
  TOP w0.381: C375.1 v2(23.52,101.27) ; PC66.2 v2(57.17,66.09) PC67.1 ; R273.2 14.98,72.95 v2(14.5,73.43) ; PC113.2 94.8,34.84 v2(94.46,35.18) ; C374.1 175.66,70.53 v2(175.16,70.03) 174.66,70.53 C373.2 ; C458.1 186.92,35.99 v2(187.55,35.36) 186.92,34.72 C467.1 ; PR55.2 172.28,130.48 v2(171.59,129.79) 170.71,130.67 170.71,130.86 ; PC78.2 67.57,45.11 PC79.2 ; C432.2 39.14,40.66 v2(38.66,40.18) ; EC60.1 175.93,11.6 175.56,11.96 C581.2 175.16,12.51 175.04,12.62 C576.2 175.04,13.2 174.66,13.57 v2(174.66,13.67) ; v2(68.98,75.75) C352.2 ; C248.2 15.95,112.46 v2(15.95,111.89) ; v2(68.35,79.3) 68.35,78.41 67.84,77.9 C347.2 ; R160.1 185.95,104.07 v2(186.08,103.95) 186.21,104.07 R161.1 ; C289.2 157.9,95.53 v2(157.54,95.88) 157.49,95.94 156.88,95.94 C288.2 C281.1 ; C372.1 15.38,71.59 v2(15.01,71.22) ; v2(65.45,24.51) 64.54,23.6 C527.2 ; C334.1 37.64,81.59 v2(38.04,81.19) ; R343.2 191.11,36.22 C464.1 191.34,34.84 v2(191.34,34.34) ; v2(185.51,96.16) 185.51,96.75 R167.1 ; C537.2 37.39,21.76 v2(37.72,22.09) 38.16,21.64 C539.2 ; v2(189.38,126.59) 189.24,126.46 EC21.2 ; v2(35.85,64.26) 35.16,64.26 C379.2 ; EC57.1 95.65,16.31 v2(95.78,16.18) ; C384.2 v2(169.19,134.42) ; v2(172.62,153.47) 172.22,153.47 EC13.2 ; v2(29.06,116.81) 28.97,116.9 C234.2 C233.2 ; 100.28,40.18 100.76,40.67 100.76,40.95 101.22,41.4 101.93,41.4 102.77,40.56 ; C378.1 88.67,64.42 v2(88.67,64.41) ; C405.2 65.17,48.3 v2(64.85,47.98) ; v2(149.25,6.5) 149.25,6.38 149.6,6.02 EC87.2 ; C315.1 39.9,91.63 v2(40.14,91.39) ; v2(175.84,15.11) 175.84,14.94 176.25,14.53 C569.2 EC61.1 ; PC1.1 v2(130.33,185.84) ; C309.1 C310.2 157.62,92.01 157.97,91.66 v2(158.18,91.66) ; EC74.2 190.2,45.77 v2(190.62,46.19) ; PC111.2 70.14,30.29 v2(70.64,30.79) ; v2(153.86,114.16) 154.13,114.16 154.73,113.56 C246.2 ; PC68.2 57.11,64.95 v2(57.17,64.88) ; v2(54.25,81.69) 54.02,81.46 C335.1 ; C369.1 173.71,76 173.18,75.46 v2(173.18,74.8) ; R309.1 189.89,56.82 190.51,56.2 190.51,56.19 v2(190.52,56.18) ; v2(66.11,27.08) 65.72,27.47 PC115.2 ; v2(98.75,33.6) 98.58,33.78 PC114.2 ; v2(73.96,85.47) 73.96,85.05 C326.2 ; EC25.1 41.16,82.07 40.84,82.39 v2(40.84,83.16) 40.51,83.16 40.3,83.37 C329.2 ; C385.2 v2(170.2,134.42) ; v2(22.74,107.22) Y2.2 ; v2(153.86,116.37) 153.06,117.17 Y1.2 ; v2(169.17,75.38) 169.33,75.38 169.7,75.75 C358.2 169.7,76.78 170.11,77.18 R258.1 ; v2(23.39,101.91) 23.52,101.91 23.9,102.29 R162.1 ; C228.2 28.38,120.08 28.48,119.98 28.48,119.78 v2(28.5,119.77) ; EC23.2 38.96,92.76 v2(38.26,92.07) ; C290.1 v2(34.06,96.57) ; EC54.2 189.84,21.79 v2(189.41,22.23) ; R204.1 v2(180.49,86.79) R205.1 ; EC65.1 177.21,10.46 C578.2 178.5,10.46 179.01,10.96 v2(179.23,10.96) ; C418.2 146.84,46.69 C416.2 146.33,46.27 v2(146.3,46.24) ; v2(88.97,169.8) 89.03,169.86 C31.1 ; v2(183.44,158.04) 183.63,158.23 EC10.2 ; C308.2 161.18,93.9 v2(161.44,93.9) ; C386.2 58.71,60.24 57.68,61.27 C383.1 ; C388.2 190.88,57.85 v2(190.88,57.71) ; v2(23.26,91.24) 23.62,90.88 VC2.2 ; C387.2 184.8,55.06 v2(185.06,55.32) ; C397.2 35.52,56.75 v2(35.28,57) ; v2(174.89,161.01) 175.03,160.87 175.03,160.3 175.03,160.29 C105.2 ; C442.2 35.97,38.81 v2(36.45,39.29) 36.95,38.79 C443.2 ; v2(40.79,98.25) 40.79,98.22 40.56,97.99 PQ12.1 ; v2(25.3,173.15) 25.29,173.16 EC4.2 ; v2(69.93,27.31) 69.34,26.71 PC117.2 ; v2(159.36,75.59) 160.03,75.59 EC26.1 ; C547.2 38.17,20.63 v2(37.62,20.07) 38.2,19.48 C552.2 ; v2(196.49,41.58) 196.62,41.45 C777.2 ; C466.2 C494.2 ; v2(60.06,74.98) 60.22,74.98 60.22,74.99 60.62,74.99 61.5,75.86 EC28.2 ; C298.2 v2(16.38,94.86) ; EC62.1 179.73,13.39 v2(179.93,13.58) ; C25.1 87.66,173.91 v2(86.16,173.91) ; v2(100.61,80.7) 100.47,80.83 PC57.1 ; v2(43.82,82.32) 43.82,81.95 C333.2 ; v2(168.44,78.66) 168.06,79.05 R240.1 C346.2 ; v2(189.24,130.73) EC20.2 ; C30.1 88.94,170.48 v2(88.97,170.51) ; C370.1 v2(25.8,99.24) ; v2(88.59,24.28) 88.59,23.99 EC50.2 87.79,23.67 C523.1 ; v2(37.42,82.73) 37.24,82.91 R223.1 ; R411.2 177.93,12.89 v2(177.93,12.97) ; C301.1 156.51,93.84 v2(157.28,94.61) 156.82,95.07 C293.1 ; v2(161.15,98.71) 160.82,98.71 160.36,99.18 C273.1 ; C362.1 78.82,75.82 v2(78.82,76.37) ; v2(190.52,55.54) 190.16,55.54 C394.2 ; C456.2 36.65,37.01 v2(36.6,36.96) 36.55,37.01 C455.2 ; 92.97,187 v2(92.23,187) ; R175.1 181.34,94.46 180.53,94.46 R174.1 180.19,94.29 v2(179.8,93.91) ; C530.2 196.56,22.39 197.05,21.9 v2(197.25,21.9) ; v2(34.6,37.32) 34.15,37.77 C451.2 ; Y1.4 151.36,114.17 v2(151.34,114.15) 151.9,113.6 C245.2 ; EC56.2 35.86,17.98 v2(35.36,17.48) ; EC30.1 19.22,74.46 v2(19.76,75.01) ; v2(70.65,88.05) 70.63,88.07 C320.1 C319.1 ; C463.1 36.59,58.92 37.26,59.59 v2(37.39,59.59) ; v2(171.22,73.38) 171.16,73.32 C367.2 ; C582.2 v2(177.82,9.32) EC69.2 ; C109.2 172.79,158.67 172.15,159.32 C106.2 171.73,159.57 171.72,159.57 v2(171.47,159.82) ; EC91.2 149.75,7.99 v2(149.17,7.42) 149.17,7.34 149.48,7.04 EC92.2 ; VC1.2 v2(15.37,94.87) ; C338.2 65.81,80.31 v2(65.81,80.7) ; v2(167.9,7.39) 168.08,7.39 EC90.2 ; R176.1 v2(17.4,94.87) ; R315.1 167.53,132 v2(168.68,132) ; PR134.2 91.18,34.72 v2(91.06,34.6) ; C60.2 25.29,174.56 v2(25.3,174.55) ; PQ1.1 114.36,182.07 v2(113.98,181.69) ; C332.2 v2(48.13,82.48) ; v2(66.77,27.08) 66.98,26.87 PC116.2 ; C2.1 v2(42.05,169.22) ; C328.2 v2(57.17,84.76) ; v2(174.34,152.73) 174.34,152.81 174.02,153.13 EC12.2 ; EC68.2 82.84,10.96 83.11,11.23 v2(83.11,11.23) ; C125.1 162.08,97.02 v2(161.48,96.43) 160.84,97.07 C282.1 ; v2(175.82,129.08) 175.03,129.08 174.78,129.34 ; PQ6.1 170.99,127.91 v2(171.58,128.5) ; C409.1 112.3,47.42 R320.2 ; R6.2 42.19,170.36 41.88,170.05 v2(41.88,169.9) ; EC22.1 v2(23.4,92.63) ; v2(188.74,63.74) 188.96,63.74 189.16,63.54 PC71.1 ; EC55.2 v2(197.91,21.27) ; v2(87.37,19.1) 87.3,19.02 87.3,18.84 86.8,18.34 ; v2(119.43,21.85) 118.88,21.3 U16.5 ; C337.2 v2(72.29,80.56) ; EC71.2 v2(34.44,7.54) ; C361.2 76.86,75.82 v2(77.4,76.36) ; C787.2 v2(34.57,52.88) ; C344.1 71.9,77.9 72.57,77.9 v2(73.43,78.77) 73.82,79.16 C340.2 ; v2(161.57,74.96) 161.57,75.99 EC27.1 ; C392.2 C393.2 82.95,58.47 82.7,58.73 v2(82.7,59.11) ; v2(91.42,185.52) 91.86,185.09 PC7.1 ; C396.2 v2(37.87,56.75) ; C565.1 163.25,19.06 163.09,19.06 163.04,19.11 C575.2 161.4,19.11 v2(161.24,18.95) ; C495.2 v2(176.18,32.22) ; R293.2 181.64,62.88 181.41,63.12 180.77,63.12 v2(180.67,63.22) ; R346.1 R345.1 184.68,34.98 184.96,34.7 v2(185.34,34.7) ; R416.1 v2(154.18,9.7) ; v2(191.08,61.98) 190.78,62.28 PR105.1 ; EC63.2 v2(82.37,11.24) ; C311.2 162.1,92.91 v2(161.82,92.63) C317.2 C316.2 ; R4.2 v2(44.22,166.93) ; C294.2 v2(161.44,94.63) ; PC103.2 v2(67.71,35.61) ; EC73.2 v2(186.58,46.25)
  TOP w0.406: C8784.1 v2(68.84,165.33)
  TOP w0.457: R148.2 145.7,115.07 v2(145.7,114.25) 145.69,114.25 R152.2 ; C526.1 v2(61.49,23.93) ; v2(60.35,24.18) C525.1
  TOP w0.508: C342.2 34.97,79.12 35.3,78.79 v2(35.3,78.31) ; R341.2 195.96,36.5 v2(196.41,36.5) ; v2(33.82,77.99) 33.92,77.89 C350.2 ; C356.2 191.8,76.84 v2(192.1,77.14) ; v2(60.29,175.46) 60.37,175.39 C40.2 ; v2(62.56,174.05) 62.74,174.23 C23.1 ; C522.2 37.35,23.35 v2(37.62,23.09) 37.92,22.78 C529.2 ; C10.1 C12.1 v2(59.59,173.6) ; v2(87.81,185.17) 87.93,185.04 PR218.2 ; PQ18.1 v2(46.48,96.22) ; Y3.4 76.13,83.71 v2(75.89,83.95) ; C115.2 v2(26.46,149.98) ; Q13.1 36.34,89.21 v2(37.01,88.54) ; v2(55.39,74.09) 55.4,74.1 55.87,74.1 L19.1 ; PC252.2 58.91,163.48 PC253.2 v2(59.54,162.38) ; C50.2 36.34,177.61 v2(36.6,177.34) ; v2(33.93,76.63) 34.05,76.51 C357.2 ; PC108.2 62.21,31.8 v2(62.06,31.95) ; PQ13.1 41.88,99.82 v2(41.5,100.2) ; v2(32.29,178.35) 32.66,177.98 C58.2 ; v2(54.2,56.62) 54.2,56.63 54.52,56.95 PR224.2 ; v2(21.59,37.87) 21.11,37.39 21.11,36.88 ; C403.2 v2(85.62,50.83) ; v2(57.62,59.46) 57.13,58.97 56.56,58.97 R304.2 ; v2(177.45,118.75) 177.45,118.44 177.04,118.03 PC37.2 175.65,118.03 PC38.2 ; PC96.2 68.61,37.25 v2(68.61,37.26) ; v2(169.82,6.88) 169.86,6.92 EC88.2 ; C258.2 29.74,111.81 v2(29.74,111.81) ; v2(149.2,9.88) v2(148.54,9.88) 148.11,10.31 C566.2 146.55,10.31 C597.2 ; R320.2 111.41,46.2 v2(111.39,46.18) ; C614.1 v2(19.71,167.31) ; v2(164.8,81.92) 165.68,81.04 165.68,79.09 R239.2 R245.2 R248.1 ; v2(57.35,68.68) 57.22,68.68 57.17,68.63 C376.1 ; Q1.1 v2(24.05,170.38) ; v2(140.22,44.37) 140.22,47.07 C413.2 ; Y3.2 74.43,79.71 v2(74.61,79.53) ; C511.2 v2(64.41,25.58) ; v2(72.9,50.5) 73.43,49.96 C399.2 ; v2(184.88,151.72) C8743.2 C8776.2 ; 181.53,30.86 181.24,30.57 181.24,25.19 179.88,23.83 179.88,22.15 C544.2 179.7,20.75 179.7,20.22 178.2,18.71 C555.2 ; C8744.2 v2(183.35,151.1) ; C497.2 v2(36.73,28.12) 36.71,28.1 EC44.2 ; C551.2 56.72,19.61 v2(56.51,19.41) ; EC70.2 v2(34.44,9.7) ; v2(87.91,166.67) C27.1 ; C472.1 121.56,36.28 v2(120.91,36.93) 120.55,36.57 C471.1 ; CN15.3 32.35,19.83 v2(32.33,19.8) ; v2(97.05,26.72) 97.05,26.09 EC49.1 ; PQ44.1 v2(51.1,161.19) ; PC251.1 v2(54.65,167.19) ; C568.2 164.3,12.76 165.4,11.66 v2(165.48,11.66) ; v2(66.85,23.93) 66.83,23.9 R372.2 ; CN11.4 v2(200.54,53.25) ; C227.2 v2(26.19,120.96) ; PC101.2 v2(69.24,35.86) ; v2(35.46,67.27) 35.16,66.97 C377.2 ; R385.1 v2(73.68,21.26) ; CN10.2 v2(174.27,136.9) ; PC95.2 v2(66.79,37.03) ; v2(60.34,14.78) C570.2 C573.2 ; R39.1 v2(56.03,171.55) ; EC67.2 34.85,10.72 34.67,10.54 v2(34.42,10.54) ; v2(187.3,64.21) 187.22,64.28 PU4.2 ; EC36.2 149.68,37.44 148.99,38.14 EC34.2 147.24,38.14 146.83,38.55 145.97,38.55 C450.2 145.83,38.4 146.02,38.21 146.02,37.33 C454.2 145.81,37.12 145.81,36.54 v2(146.01,36.34) ; v2(70.71,31.7) 70.54,31.7 PC109.2 ; v2(62.06,30.91) 62.75,30.91 PC110.2 ; C516.2 36.73,24.94 C518.1 v2(35.33,25.58) ; C536.2 35.42,21.76 v2(35.41,21.75) ; R251.2 R250.2 R249.2 126.93,75.9 v2(126.95,75.87) ; v2(45.39,158.82) PR245.2 ; C528.1 65.81,23.93 v2(65.94,24.05) ; C281.1 156.64,97.6 156.64,97.97 C274.2 ; v2(142.38,36.39) 141.92,36.39 141.26,37.06 C452.2 C448.2 ; CN10.1 v2(174.23,135.9) ; v2(73.99,18.14) 74.92,17.2 EC59.2 ; v2(36.73,30.71) 37.16,30.28 C493.2 ; v2(182.47,62.79) 182.73,62.54 PC74.2 ; v2(59.59,59.54) 59.01,60.12 C386.2 ; R419.1 163.99,10.73 163.73,10.47 v2(163.73,10.21) ; EC37.1 91.24,23.52 v2(91.84,22.91) ; C365.2 34.08,75.1 v2(33.83,75.35) ; C321.2 16.52,86.28 v2(16.53,86.28) ; EC5.1 v2(31.52,178.36) ; PQ14.1 36.57,99.49 v2(37.21,100.13) ; v2(163.88,17.12) 163.85,17.1 163.55,17.1 162.75,16.3 C572.2 ; EC33.2 137.39,38.27 137.55,38.43 C447.2 EC35.2 138.14,36.76 138.55,36.35 v2(139.72,36.35) ; C492.2 36.7,31.42 v2(36.68,31.39) 36.18,31.39 EC41.2 ; PC92.2 v2(66.31,37.63) ; Q37.1 193.93,102.18 v2(193.01,101.27) ; v2(31.81,91.24) 31.93,91.12 EC24.1 ; PC104.2 65.72,34.1 v2(66.06,33.76) ; C434.1 194.23,40.69 v2(194.82,40.11) ; v2(179.68,63.78) 179.09,64.36 179.09,64.82 ; v2(145.54,5.5) C579.2 C580.2 148.14,5.5 C1027.1 148.54,5.11 v2(149.4,5.11) 151.75,5.11 R7482.1 ; C509.2 37.13,25.96 v2(36.63,26.47) ; C491.1 187.16,31.94 v2(187.42,31.68) ; v5(196.49,30.66) 196.99,30.16 C786.2 ; D7.2 v2(59.97,64.14) ; v2(60.06,74.98) 59.71,74.98 59.46,75.24 C363.2 ; C542.1 C557.1 ; C461.2 37.11,35.48 v2(37.56,35.94) 38.02,35.48 C462.2 ; CN16.3 174.25,18.45 174.01,18.21 173.12,18.21 172.67,17.75 v2(172.67,17.55) 172.64,17.58 C577.2 ; v2(76.48,63.35) 76.93,63.8 C380.1 C381.1 ; v2(22.38,171.12) 22.25,171.25 C70.1 ; PC80.2 v2(62.06,42.09) ; R145.1 17.48,119.77 v2(17.02,119.77) ; C1028.2 v2(144.68,5.26) ; v2(143.96,36.5) 143.54,36.92 C453.2 C449.2 ; PQ40.1 59.92,55.45 v2(60.37,54.99) ; EC58.2 v2(65.94,13.26) ; v2(30.38,178.36) C69.1 ; C489.2 38.02,32.44 v2(37.59,32.87) 37.16,32.44 C488.2 ; v2(79.78,50.98) 79.12,50.32 C400.2 ; v2(172.39,6.81) 172.28,6.92 EC89.2 ; v2(72.67,41.91) 72.21,41.45 PC82.2 ; PQ41.1 v2(47.34,163.09) ; C498.2 36.78,27.1 v2(36.68,27.2) ; PC236.2 92.39,174.31 92.38,174.32 v2(92.38,174.52) ; C775.2 v2(199.06,46.89) ; v2(17.8,176.33) 18.18,176.33 18.96,175.56 C28.1 ; v2(62.05,30.15) 62.5,30.15 PC112.2 ; VC6.2 61.24,90.93 v2(60.58,91.59) ; v2(62.06,40.95) PC85.2 ; C402.2 v2(64.03,47.99) ; v2(57.3,69.77) R284.2 ; C481.2 37.26,33.96 v2(37.64,34.34) 38.02,33.96 C482.2 ; v2(66.35,42.77) 66.58,43.01 PC79.2 ; PC77.2 69.24,46.48 69.11,46.61 v2(69.11,46.71) ; CN11.2 v2(200.54,51.65) ; v2(69.14,172.67) 68.88,172.67 68.55,173 C810.2 ; C538.2 v2(57.17,23.16) ; C404.2 86.64,50.8 v2(86.66,50.83) ; v2(35.28,27.33) 35.25,27.36 35.23,27.36 35.2,27.33 CN15.6 ; v2(16.66,89.33) 16.65,89.34 C318.2 ; Q18.1 191.67,73.76 191.66,73.76 191.66,74.55 v2(191.65,74.56) ; C567.2 v2(154.58,11.1) ; v2(60.06,74.35) 59.93,74.22 C366.1 ; C345.2 v2(56.04,78.84) ; v2(186.33,23.14) U17.2 ; v2(74.31,23.93) C524.1 ; C247.2 v2(28.36,113.84) ; v2(196.21,98.53) 196.21,97.97 195.87,97.63 R166.2 ; CN12.2 v2(38.5,54.5) ; CN31.1 v2(187.27,149.22) ; PR248.2 v2(52.63,160.98) ; PC250.1 v2(53.82,160.98) ; PC86.2 72.24,40.44 73.28,41.48 v2(73.28,41.66) ; CN12.3 v2(38.5,55.5) ; PC11.2 v2(125.63,185.73) PC10.2 ; v2(57.44,171.02) C8781.1 ; U22.2 v2(144.04,7.93) ; C8742.2 63.48,172.18 64.18,172.88 R8515.2 64.39,173.09 EC3.1 65.99,174.23 v2(66.17,174.05) ; C313.2 v2(16.03,92.51) ; C496.2 37.08,29.26 v2(36.65,28.83) ; v2(35.84,14.53) Q28.1 ; PQ42.1 v2(44.8,158.12) ; CN5.4 v2(33.8,173.29) ; v2(75.68,19.59) 75.68,19.37 75.28,18.97 C554.1 ; CN5.5 v2(34.8,173.3) ; EC19.2 v2(20.98,148.13) ; C175.2 v2(185.15,73.24) ; C314.2 v2(17.04,92.51) ; C773.2 v2(196.49,44.09) ; PC87.2 v2(62.06,39.93)
  BOTTOM w0.102: U25.C11 161.52,104.35 161.52,105.01 161.52,105.02 161.52,105.48 U25.A11
  BOTTOM w0.127: 142.2,85.23 142.06,85.09 141.96,84.98 141.96,84.71 141.59,84.34 U25.AV43 ; 143.54,85.15 143.69,85.15 143.83,85.29 U25.AT40 ; 143.54,85.15 142.89,85.15 U25.AT42 ; 143.54,85.15 143.54,84.71 143.17,84.34 U25.AV41 ; v2(33.75,8.97) 33.96,9.17 34.87,9.17 35.53,8.51 36.7,8.51 38.83,10.64 38.83,11.02 39.1,11.29 39.58,11.29 39.72,11.15 46.43,11.15 46.61,11.33 46.61,15.16 47.57,16.13 51.33,16.13 51.56,15.9 v2(51.76,15.9) v2(55.6,15.9) 59.22,15.9 v2(60.34,14.78) 60.34,15.86 59.18,17.02 v2(58.88,17.02) v2(55.5,17.02) v2(50.75,17.02) 47.19,17.02 v2(46.06,15.89) 45.12,15.89 42.37,13.13 v2(42.11,13.13) 41.07,12.09 37.49,12.09 35.94,10.54 v2(34.42,10.54) ; 138.91,85.18 138.91,85.06 138.81,84.96 138.81,84.71 138.44,84.34 U25.AV49 ; U25.AH17 158.28,89.96 158.41,89.96 158.43,89.94 158.78,89.94 158.8,89.96 158.93,89.96 U25.AH16 ; v2(149.6,82.11) 149.6,82.39 149.81,82.6 U25.AY30 ; U25.AY57 133.14,83.2 133.14,82.33 v2(133.03,82.23) ; v2(57.17,23.16) 56.4,23.94 50.28,23.94 v2(49.88,24.34) 49.5,24.71 v2(44.83,24.71) 42.58,24.71 41.81,23.94 37.56,23.94 37.3,24.2 37.3,24.24 36.98,24.56 33.86,24.56 33.25,25.17 31.62,25.17 31.29,24.84 31.29,24.46 v2(32,23.75) 32.1,23.65 36.7,23.65 37.26,23.09 v2(37.62,23.09) 38.09,23.09 38.46,22.72 v2(45.13,22.72) v2(51.23,22.72) 51.37,22.58 v2(55.45,22.58) ; v2(166.27,85.93) 165.22,85.93 U25.AR5 ; U25.AV39 144.74,84.26 145.11,84.63 145.11,85.26 ; 146.69,85.18 146.69,84.71 146.32,84.34 U25.AV36 ; v2(153.55,82.28) 153.6,82.32 U25.AY24 ; 140.37,85.29 140.37,84.98 140.38,84.97 140.38,84.71 140.02,84.34 U25.AV46 ; v2(128.26,86.7) 128.61,86.7 129.03,87.11 129.6,87.11 U25.AN63 ; v2(46.25,178.74) C21.1
  BOTTOM w0.14: 144.71,84.19 144.64,84.19 v2(144.32,83.87) 143.99,83.54 U25.AW40 ; U25.AU22 U25.AU20 U25.AU18 ; U25.AR23 154.52,86 155.18,86.65 U25.AP22
  BOTTOM w0.152: U25.AJ60 131.56,89.13 131.57,89.13 131.57,88.85 131.56,88.85 U25.AL60 ; v2(135.69,81.95) 135.58,82.06 U25.AY53 ; U25.AU24 153.59,85.17 152.72,85.17 152.69,85.14 152.27,85.14 U25.AU26 ; U25.AU24 154.13,85.16 154.13,85.17 154.41,85.17 154.41,85.16 U25.AU22 ; U25.AU24 153.6,85.21 U25.AR23 ; v2(152.05,82.05) 152.24,82.24 U25.AY26 ; v2(127.77,89.09) 128.12,89.44 128.84,89.44 128.96,89.56 U25.AJ63 ; U25.AY22 154.95,82.2 v2(155.05,82.1) ; 138.07,86 137.97,86 137.72,85.75 ; U25.G3 166.28,101.66 165.83,101.66 165.76,101.6 U25.G5 ; U25.W22 U25.W20 ; U25.AY18 157.38,82.31 v2(157.43,82.27) ; v2(153.88,92.89) 154,93.02 154,93.14 154.48,93.62 U25.AB22
  BOTTOM w0.178: v2(145.83,87.1) 145.85,87.1 146.05,87.3 U25.AN36 ; v2(131.96,89.9) 131.75,90.11 131.75,90.72 131.75,90.73 U25.AG60 ; v2(131.96,89.9) U25.AJ58 132.54,89.92 132.84,90.23 U25.AH57 133.51,90.23 133.83,89.9 U25.AJ56 ; v2(131.96,89.9) 131.62,89.56 U25.AJ60 ; U25.AU30 149.3,85.16 149.28,85.18 U25.AU33 148.3,85.18 148.05,85.44 147.75,85.74 ; U25.AU30 149.53,85.45 149.53,86.2 U25.AR31 149.53,86.45 149.53,86.85 U25.AP31 149.55,87.07 149.55,87.52 U25.AN31 ; U25.AU30 150.22,85.16 150.24,85.18 150.53,85.18 150.54,85.16 U25.AU28 151.52,85.16 151.53,85.18 151.82,85.18 151.84,85.16 U25.AU26 ; U25.AW33 148.22,83.86 U25.AV34 ; U25.AW33 148.46,84.46 U25.AV33 148.22,84.51 U25.AV34 ; U25.AW33 U25.AY33 ; U25.Y63 129.13,94.74 v2(128.68,94.74) ; U25.AV34 147.81,84.19 v2(147.49,83.86) 147.16,83.54 U25.AW35 ; U25.AB7 164.16,93.64 v2(164.16,93.94) ; 147.75,85.74 147.48,85.47 U25.AT35 147.36,85.18 146.39,85.18 146.27,85.29 U25.AT37 145.14,85.29 145.07,85.23 144.39,85.23 U25.AT40 ; 147.75,85.74 147.79,85.78 147.97,85.78 U25.AR33 ; v2(139.62,89.67) 139.52,89.67 139.29,89.9 U25.AJ47 ; v2(139.62,89.67) 139.62,90.16 U25.AH46 ; v2(139.62,89.67) 140.11,89.67 U25.AJ45 ; U25.AU16 U25.AV16 U25.AW16 158.69,83.25 U25.AY16 ; U25.H57 132.86,101.81 132.76,101.91 132.76,102.17 U25.F58 132.54,102.76 132.23,103.06 132.23,103.35 U25.D59 132.01,103.67 131.48,104.2 v2(131.48,104.4) ; v2(130.4,88.31) 130.44,88.35 U25.AL61 U25.AL60 131.56,87.86 131.58,87.84 131.58,87.56 131.56,87.54 131.56,87.22 131.56,87.21 U25.AN60 ; U25.AN31 149.53,87.75 149.53,88.15 U25.AM31 149.55,88.37 149.55,88.82 U25.AL31 ; U25.AN31 149.42,87.62 149.09,87.3 U25.AN32 149.03,87.3 148.7,86.97 148.7,86.97 v2(148.69,86.96) ; v2(147.74,88.23) 147.82,88.23 U25.AL33 ; U25.AU53 136.1,85.16 136.12,85.18 136.4,85.18 136.42,85.16 U25.AU51 U25.AV51 U25.AW51 U25.AY51 ; U25.AU53 135.17,85.16 135.16,85.18 134.87,85.18 134.85,85.16 U25.AU55 ; U25.AU53 135.58,85.25 U25.AR52 136.17,86.16 136.17,86.43 136.33,86.59 U25.AP52 ; U25.AY24 U25.AW24 U25.AV24 ; v2(128.08,100.92) 128.48,100.51 129.24,100.51 129.29,100.56 U25.J63 ; U25.AT49 138.07,85.2 138.89,85.2 138.91,85.18 138.97,85.23 139.54,85.23 U25.AT46 140.37,85.29 140.48,85.18 141.06,85.18 U25.AT43 141.27,85.2 142.17,85.2 142.2,85.23 142.69,85.23 U25.AT42 ; U25.AU59 132.32,85.16 132.33,85.18 132.62,85.18 132.64,85.16 U25.AU57 133.56,85.16 133.58,85.18 133.86,85.18 133.88,85.16 U25.AU55 ; U25.AV59 U25.AW59 ; v2(139.6,83.21) 139.45,83.21 139.19,83.46 U25.AW47 ; U25.AV43 141.59,84.18 141.27,83.87 141.21,83.87 v2(141.2,83.86) 140.88,83.54 U25.AW44 ; 137.72,85.75 137.69,85.72 ; 135.81,88.27 136.14,88.6 U25.AL52 ; v2(128.17,98.01) 128.61,97.58 128.99,97.58 129,97.58 U25.P63 ; U25.AU55 U25.AV55 ; U25.AL36 146.01,88.6 145.97,88.55 145.84,88.43 v2(145.79,88.43) ; U25.AJ52 136.44,89.36 U25.AK52 135.97,89.25 135.81,89.08 ; U25.AR49 138.07,86 ; v2(132.33,100.18) 131.97,100.54 U25.J59 ; U25.J10 162.45,99.74 161.48,98.76 ; U25.M22 154.31,98.5 154.21,98.39 v2(154.21,98.41) ; U25.AR17 U25.AP17 U25.AN17 U25.AM17 158.62,88.35 158.62,88.86 U25.AL17 ; U25.AV41 143.07,84.19 v2(142.74,83.86) 142.42,83.54 U25.AW42 ; U25.AD63 129.28,92.35 v2(128.78,92.35)
  BOTTOM w0.203: v2(166.92,94.92) 166.91,94.92 166.61,95.22 U25.V3 ; U25.B52 U25.A52 136.4,105.25 136.4,105.56 v2(136.53,105.69) ; U25.AY11 161.54,82.25 v2(161.79,82) ; 161.48,98.76 161.43,98.71 v2(161.15,98.71) ; v2(137.7,86.99) 137.46,86.99 U25.AN51 ; U25.T1 168.4,96.8 v2(168.53,96.66) ; v2(141.55,85.69) 141.57,85.69 ; 141.57,85.69 141.88,86 U25.AR43 ; 141.57,85.69 141.18,85.3 U25.AT43 ; U25.AR39 144.37,85.34 U25.AT40 ; U25.AR39 145.07,86.32 145.28,86.53 U25.AP38 145.35,86.65 145.8,87.1 v2(145.83,87.1) ; U25.AR39 U25.AP39 U25.AN39 ; U25.AN39 144.11,87.62 U25.AN40 ; U25.AN39 144.37,88.01 U25.AL40 ; U25.AL23 154.33,88.65 154.33,89.19 U25.AK23 ; U25.A36 146.34,105.16 146.34,104.6 U25.B36 146.37,104.18 v2(146.52,104.02) ; U25.AN49 138.47,86.98 v2(138.66,86.98) ; v2(156.18,83.99) 156.18,84.49 U25.AV20 ; U25.N3 166.61,98.22 v2(166.91,97.92) ; U25.AL51 137.09,88.6 v2(136.76,88.27) ; U25.AW59 131.59,83.54 U25.AW60 ; U25.AC61 130.29,93.35 v2(130.29,93.46) ; U25.AN46 139.84,87.3 v2(139.62,87.08) ; U25.AR23 U25.AP23 154.23,86.8 154.23,87.14 U25.AN23 154.3,87.38 154.3,87.87 U25.AM23 ; v2(141.49,105.68) 141.35,105.55 U25.A44 U25.B44 ; v2(131.69,82) 131.83,82.14 U25.AY59 ; U25.E17 158.6,102.9 v2(158.2,103.3) ; Q41.4 194.24,100.45 194.56,100.13 195.35,100.13 195.54,99.93 Q41.1 ; U25.AN43 142.33,86.99 v2(142.47,86.99) 142.69,86.99 142.97,87.27 U25.AN42 ; v2(146.78,86.96) 146.85,86.96 147.18,87.3 U25.AN35 ; v2(132.93,88.31) 133.09,88.31 133.38,88.6 U25.AL57 ; v2(166.19,103.89) 166.23,103.86 166.85,103.86 U25.D2 ; U25.AV59 U25.AU59 131.7,85.37 131.7,85.53 131.43,85.81 v2(131.43,85.98) 131.6,86.15 131.6,86.6 131.56,86.63 U25.AN60 ; U25.K1 168.43,99.79 v2(168.45,99.81) ; v2(136.75,86.97) 136.63,86.97 136.33,86.67 U25.AP52 ; v2(168.55,84.66) 168.43,84.79 167.99,84.79 U25.AU1 ; U25.B32 148.85,104.56 148.85,105.17 U25.A32 ; v2(168.49,87.86) 168.44,87.8 U25.AM1 ; U25.AL29 150.55,88.66 150.25,88.96 v2(150.16,88.96) ; U25.AL46 140.11,88.57 140.37,88.32 v2(140.57,88.32) 140.76,88.32 U25.AL45 ; U25.AN48 139.47,87.71 v2(139.62,87.71) ; U25.B48 138.73,104.65 138.73,105.08 U25.A48 138.66,105.38 v2(138.66,105.68) ; U25.F61 130.29,102.34 v2(130.29,102.45) ; 135.81,88.27 136.01,88.27 U25.AM52 ; U25.AV14 160.01,84.19 159.7,84.51 159.7,84.51 v2(159.67,84.54)
  BOTTOM w0.254: v2(126.74,24.64) 126.45,24.93 JDIM2.48 ; U25.AP10 162.58,87.11 v2(162.65,87.11) ; U25.AF12 161.04,91.13 U25.AG11 161.85,91.13 U25.AF11 ; U25.AP26 152.77,86.96 v2(152.86,86.96) ; U25.B60 131.29,104.82 131.29,104.8 131.48,104.6 v2(131.48,104.4) ; U25.A40 U25.B40 143.86,104.07 v2(143.8,104) ; U25.D25 152.87,103.24 U25.D26 U25.F26 152.64,101.79 v2(152.54,101.69) ; U25.C25 152.87,104.54 U25.B26 152.64,105.02 v2(152.59,105.06) ; 161.22,88.25 160.73,88.74 U25.AL13 ; 161.22,88.25 161.22,88.47 161.56,88.82 162.17,88.82 U25.AL10 ; 161.22,88.25 v2(161.22,88.23) ; U25.AV8 162.96,84.19 v2(162.67,84.48) ; U25.AK3 166.92,89.04 v2(166.92,88.92) ; v2(138.04,83.22) 137.88,83.22 137.62,83.49 U25.AW50 ; v2(166.95,81.76) 166.58,81.76 165.99,82.36 U25.AY4 165.99,83.5 U25.AW4 ; U25.AK23 154.8,89.66 U25.AJ23 ; R495.1 120.67,104.32 v2(120.55,104.45) ; v2(161.44,93.9) 161.82,93.9 162.26,93.46 U25.AB10 ; U25.AW37 145.49,83.56 145.79,83.86 v2(145.91,83.86) 145.96,83.86 146.29,84.19 U25.AV36 ; v2(142.25,101.52) 142.61,101.87 U25.F42 U25.D42 142.93,103.56 U25.D41 143.25,103.56 143.69,104 v2(143.8,104) ; v2(157.28,94.61) 157.28,94.16 U25.AB20 ; U25.AL23 154.49,88.6 v2(154.81,88.27) ; v2(159.27,85.76) 159.72,85.76 U25.AR15 ; v2(159.27,85.76) 159.04,85.76 158.69,86.11 U25.AR17 ; v2(159.27,85.76) 159.27,85.48 158.95,85.16 U25.AU16 ; U25.AT63 129.59,85.67 129.75,85.82 U25.AT62 130.86,85.82 U25.AT61 131.01,85.98 v2(131.43,85.98) ; U25.AN45 141.41,87.66 v2(141.54,87.66) ; U26.2 183.67,93.12 183.29,93.5 v2(183.29,93.78) ; v2(156.72,86.97) 156.73,86.97 156.73,86.98 156.78,86.98 U25.AP20 ; U25.J22 155.31,100.08 155.76,99.62 155.76,99.37 ; U25.C11 161.18,103.94 U25.D12 U25.D14 160.39,103.91 U25.C14 160,104.33 160,105.03 159.88,105.15 U25.A14 159.71,105.69 v2(159.71,106.15) ; JDIM2.196 173.25,28.58 172.64,29.18 v2(172.52,29.18) ; v2(150.74,90.46) 150.33,90.46 U25.AH30 ; v2(150.74,90.46) 151.16,90.46 U25.AH28 151.72,90.23 U25.AJ27 ; v2(150.74,90.46) U25.AJ29 ; v2(147.77,101.59) 147.62,101.74 U25.F34 U25.D34 ; 137.69,85.72 138,85.4 U25.AT49 ; 137.69,85.72 v2(137.7,85.72) ; 137.69,85.72 137.13,85.16 U25.AU51 ; JDIM2.138 155.85,24.72 v2(155.93,24.64) ; v2(140.1,101.7) U25.F46 U25.D46 ; U25.AJ45 140.66,90.23 U25.AH44 141.09,90.13 141.41,90.13 U25.AJ43 141.88,89.66 v2(142.34,89.66) ; JDIM2.128 152.85,27.53 v2(153.06,27.74) ; U25.D39 144.88,103.24 U25.D38 ; U25.D39 144.79,103.56 U25.C38 145.35,103.89 U25.D37 145.35,103.24 U25.D38 ; U25.D39 U25.C39 144.34,104 v2(143.8,104) ; U25.R22 U25.U22 155.21,96.06 U25.V23 154.9,95.65 U25.W22 ; U25.G8 163.58,101.6 163.84,101.33 164.1,101.33 U25.G6 164.36,101.6 164.36,101.71 164.65,101.99 v2(164.84,101.99) 164.92,101.99 U25.G5 ; v2(150.16,86.97) 150.13,86.97 150.13,86.97 150.23,86.97 U25.AP29 ; U25.L18 U25.L17 U25.L15 159.6,99.14 159.45,98.99 159.45,98.22 159.85,97.82 v2(160,97.82) ; U25.G22 155.31,101.91 v2(155.81,102.41) ; U25.P63 U25.P62 ; U25.AR11 161.69,85.69 v2(161.3,85.29) 160.53,85.29 U25.AT13 ; v2(133.88,86.98) 133.79,86.98 133.46,86.65 U25.AP57 ; U25.U61 130.93,96.39 v2(130.93,96.47) ; PD8.2 103.45,174.5 103.21,174.26 102.84,174.26 v2(102.53,174.56) ; EC9.2 97.84,174.47 v2(98.4,173.91) 98.86,174.37 EC7.2 ; v2(121.56,24.56) 121.65,24.65 JDIM2.32 ; v2(131.58,97.95) 131.89,97.65 U25.P59 ; v2(111.39,46.18) 112.44,46.18 112.95,46.68 JDIM1.3 ; U25.V7 163.98,95.65 v2(164.17,95.84) ; v2(152.04,88.28) 152.05,88.28 152.38,88.6 U25.AL26 ; C717.2 192.95,100.16 192.17,99.38 EC76.2 ; v2(155.81,102.41) 156.57,102.41 U25.F20 ; v2(155.81,102.41) 155.68,102.54 U25.D21 ; v2(157.81,106.67) 157.81,106.48 157.31,105.98 U25.A18 157.31,105.15 157.42,105.03 157.42,104.71 157.41,104.7 U25.C18 ; U25.AJ41 142.7,89.66 v2(142.34,89.66) ; v2(154.31,104.19) 154.54,103.96 U25.D23 ; v2(142.34,89.66) 142.34,90.17 U25.AH42 ; v2(158.2,103.3) 157.81,103.68 U25.D18 ; U25.AV39 144.71,84.19 ; U25.D38 U25.F38 v2(145.11,101.7) ; PR210.1 PR206.1 72.75,174.98 74.42,174.98 75.54,176.1 v2(75.92,176.1) ; U25.AD21 156.23,92.42 155.86,92.79 155.86,92.96 155.31,93.51 U25.AB22 ; PR167.2 195.98,67.64 v2(195.88,67.74) 195.84,67.7 PU10.4 ; U25.D27 151.84,103.56 v2(151.39,104.01) ; U25.AF11 161.71,91.38 161.71,92.52 v2(161.82,92.63) ; U25.AF11 162.11,91.23 U25.AE10 ; U25.B20 156.4,104.53 U25.C20 156.43,104.29 156.89,104.29 157.29,103.89 157.29,103.36 v2(157.2,103.28) ; v2(161.95,95.94) 162.08,95.81 162.08,95.73 U25.V10 162.88,95.81 U25.U9 ; U25.L58 132.33,99.59 v2(132.33,100.18) ; EC8.2 100.89,174.42 v2(100.33,173.86) 99.87,174.32 EC6.2 ; U25.H13 160.55,101.02 160.3,101.27 v2(160.16,101.27) ; U25.D35 147.3,103.56 U25.D34 ; v2(151.48,106.08) 151.35,105.94 151.35,105.23 U25.A28 U25.B28 ; PD9.2 80.33,172.34 PC231.2 ; v2(128.53,24.63) 128.25,24.91 JDIM2.54 ; 155.76,99.37 156.67,99.37 U25.L20 ; 155.76,99.37 155.76,98.88 ; U25.AJ39 144.57,90.23 U25.AH38 ; U25.AJ39 144.03,90.11 144.03,90.4 v2(144.11,90.48) 143.85,90.48 U25.AH40 ; U25.AJ39 144.37,89.77 U25.AL39 144.05,88.6 U25.AL40 143.78,88.54 143.52,88.27 v2(143.38,88.27) ; U25.AL13 160.64,89.04 U25.AJ13 ; U25.AL13 159.82,89.25 U25.AJ14 ; U25.AN52 136.22,87.3 135.89,86.97 v2(135.8,86.97) 135.48,86.65 U25.AP54 135.26,86.65 134.91,86.29 v2(134.86,86.29) ; U25.T58 133.05,96.79 v2(133.28,96.55) ; JDIM2.136 155.25,24.9 v2(154.99,24.64) 154.65,24.98 JDIM2.134 ; U25.AL54 135.49,88.6 135.81,88.27 v2(135.81,88.27) ; U25.AF18 157.79,91.29 158.16,91.66 v2(158.18,91.66) 158.23,91.66 158.6,91.28 U25.AF17 ; v2(151.39,104.01) 151.48,104.01 151.69,104.21 U25.C27 ; v2(151.39,104.01) 151.27,104.01 150.83,103.56 U25.D29 ; JDIM2.46 125.85,24.99 125.49,24.63 v2(125.28,24.63) 125.25,24.66 JDIM2.44 ; U25.L61 130.94,99.4 v2(130.94,99.46) ; v2(154.81,88.27) 154.88,88.27 U25.AL22 ; v2(154.81,88.27) 154.71,88.27 U25.AM23 ; U25.AL20 157.11,88.71 156.89,88.93 v2(156.69,88.93) ; U25.D5 165.42,103.86 166.16,103.86 v2(166.19,103.89) 166.19,104.66 U25.B4 ; U25.G18 158.02,101.27 v2(158.15,101.27) 158.32,101.27 U25.H17 ; v2(153.58,105.87) 153.63,105.82 153.63,105.48 153.89,105.21 U25.A24 153.73,105.03 153.73,104.7 U25.B24 ; U25.AV28 151.03,84.04 v2(151.06,84) ; JDIM2.66 131.85,24.65 v2(131.83,24.63) ; U25.D43 141.6,104 v2(141.23,104) 140.79,103.56 U25.D45 ; v2(155.71,89.56) 155.96,89.81 U25.AG21 156.31,90.04 U25.AH20 ; JDIM2.178 167.85,27.8 v2(167.33,28.32) ; U25.AG63 U25.AG62 U25.AG61 U25.AG60 ; v2(161.59,106.03) 161.6,106.03 161.6,105.56 U25.A11 ; JDIM2.60 130.05,24.79 v2(129.89,24.63) ; JDIM2.72 133.65,24.72 v2(133.56,24.63) ; v2(128.71,103.56) 128.73,103.54 U25.D63 129.34,103.48 U25.D62 ; U25.D47 139.34,103.56 138.89,104.01 v2(138.73,104.01) 138.28,103.56 U25.D49 ; U25.AH49 138.5,90.11 v2(138.5,89.67) ; v2(137.55,101.57) 137.59,101.61 U25.F50 U25.D50 ; v2(192.08,71.17) 192.08,70.91 192.67,70.32 PU10.19 ; v2(148.7,89.67) 148.7,90.13 U25.AH32 ; 155.76,98.88 155.76,98.71 156.23,98.25 U25.N21 ; 155.76,98.88 155.38,98.5 U25.M22 U25.P22 ; U25.AJ35 146.84,90.46 v2(146.87,90.48) 147.23,90.48 U25.AH34 147.54,90.17 147.54,89.67 147.55,89.67 v2(147.55,89.68) ; v2(146.06,89.69) 146.18,89.81 146.18,90.21 U25.AH36 ; U25.AG23 154.22,90.77 v2(154.21,90.76) 153.99,90.54 U25.AH24 ; U25.D33 147.95,103.56 U25.D34 ; v2(138.5,89.67) 137.97,89.67 U25.AJ50 137.41,89.9 U25.AH51 136.76,89.9 U25.AJ52 ; v2(138.5,89.67) 138.81,89.67 U25.AJ47 ; v2(133.66,105.67) 133.66,105.36 U25.A56 U25.B56 133.51,104.21 U25.C57 U25.D57 ; PR174.2 54.36,54.41 v2(54.07,54.12) ; U25.AA58 132.25,94.18 U25.Y59 131.89,94.64 v2(131.56,94.96) ; U25.AH19 157.7,90.35 v2(157.79,90.35) 157.88,90.35 U25.AH17 ; R593.2 169.92,76.01 169.92,75.39 v2(170.2,75.11) ; JDIM2.162 163.05,24.96 v2(162.71,24.62) ; v2(159.48,24.64) 159.45,24.67 JDIM2.150 ; U25.D8 163.76,103.31 v2(163.84,103.23) ; U25.D55 134.76,103.56 U25.D54 U25.F54 135.08,101.8 v2(135.11,101.77) ; U25.V58 133.02,95.49 v2(133.24,95.27) ; v2(135.81,89.08) 135.81,89.08 135.79,89.1 U25.AH53 135.46,89.9 U25.AJ54 134.81,89.9 U25.AH55 134.16,89.9 U25.AJ56 ; U25.D51 136.6,103.99 136.56,104.03 v2(136.5,104.03) 136.15,104.03 135.69,103.56 U25.D53 ; Q41.1 195.54,98.92 195.93,98.53 v2(196.21,98.53) ; v2(157.66,24.64) 157.65,24.64 JDIM2.144 ; U25.AE5 165.28,91.57 v2(165.63,91.92) ; JDIM2.156 161.25,24.65 v2(161.26,24.64) ; v2(169.11,93.22) 169.11,93.32 168.6,93.84 167.95,93.84 U25.AA1 ; U25.K12 160.99,99.81 U25.L13 160.55,99.31 v2(161.15,98.71) 161.64,98.22 U25.N10 ; U25.U20 157.37,96.06 v2(157.54,95.88) 156.9,95.24 U25.W20 ; U25.L7 163.65,98.85 v2(163.65,98.62) ; v2(150.13,101.7) U25.F30 U25.D30 ; v2(159.89,91.92) 159.42,91.45 U25.AF15 U25.AF14 ; U25.R10 U25.R8 ; U25.AG1 v2(168.43,90.8) ; U25.AL31 149.7,88.97 150.15,88.97 v2(150.16,88.96) ; JDIM2.168 v2(164.85,27.74) ; JDIM2.38 123.45,25.03 123.14,24.71 v2(123.14,24.63) ; v2(143.37,86.96) 143.47,86.96 143.78,87.27 U25.AN40 ; v2(166.92,91.92) 166.92,92.03 U25.AD3
  BOTTOM w0.305: U25.AP3 166.61,86.25 166.31,85.94 166.32,85.93 v2(166.27,85.93) ; U25.AJ25 153.54,89.9 154.05,89.39 arc(154.2,89.28) 154.38,89.25 U25.AK23 ; v2(202.46,26.47) 202.21,26.72 EC78.2 ; U25.B32 v2(148.88,104.01) 149.02,104.01 149.47,103.56 U25.D31 ; U25.R10 161.59,96.43 v2(161.48,96.43) ; U25.AY6 164.54,82.19 v2(164.8,81.92) ; JDIM2.190 v2(171.45,28.47) ; v2(133.39,92.04) 132.94,91.58 U25.AE58 ; v2(161.98,103.22) 161.83,103.22 U25.E11 ; U25.AN7 164.48,87.74 v2(164.59,87.74) ; v2(169.98,28.45) 169.65,28.12 JDIM2.184 ; CN29.39 103.16,24.45 ; v2(161.44,94.63) 161.47,94.67 162.19,94.67 U25.Y10 ; CN29.51 103.24,27.45 ; v2(155.71,89.56) 155.31,89.96 U25.AH22 ; v2(138.67,86.32) 138.73,86.32 U25.AP48 ; CN29.45 103.14,25.95
  BOTTOM w0.356: JDIM2.172 v2(166.05,27.65) 165.8,27.65 165.45,27.3 JDIM2.170 ; JDIM2.2 112.65,27.7 v2(113.16,28.21)
  BOTTOM w0.381: v2(169.17,75.38) 169.07,75.47 C741.1 ; v2(121.16,91.44) 121.16,91.03 121.05,90.92 R562.1 R564.1 ; v2(183.16,91.85) 183.02,91.71 C726.1 ; v2(179.8,93.91) 180.35,93.35 C724.1 ; J1.2 175.14,75.18 v2(175.51,74.8) ; C7748.1 v2(46.12,181.92) ; v2(159.67,113.67) 160.17,114.17 C708.1 160.29,114.34 161.07,115.12 R484.2 ; v2(120.55,100.91) 121.07,100.91 R508.2 ; v2(18.69,72.7) 18.95,72.95 R592.1 ; U25.H57 133.53,101.41 v2(133.77,101.65) ; PR72.1 96.04,82.47 v2(96.29,82.22) ; C653.1 179.61,153.6 v2(179.96,153.95) ; v2(173.66,38.02) 173.25,38.44 JDIM1.196 ; R454.2 16.25,160.55 v2(16.41,160.71) ; EC79.2 200.19,27.22 v2(200.18,27.23) ; C707.2 157.37,114.99 v2(157.37,115.49) ; C719.1 112.34,95.68 v2(112.11,95.91) ; v2(167.79,112.83) 167.79,114.34 167.55,114.34 R483.2 ; U27.1 19.79,45.2 19.77,45.22 19.79,45.25 19.94,45.25 v2(19.96,45.27) ; PR183.2 v2(39.27,46.03) ; C718.1 120.93,96.14 v2(120.46,95.68) 121.05,95.09 R542.2 ; v2(44.91,178.35) 44.21,179.04 C7747.2 ; v2(188.57,103.32) 188.5,103.25 C716.2 ; C713.1 180.24,107.1 R492.2 ; R492.2 179.74,106.4 v2(179.37,106.03) ; R492.2 180.3,106.04 180.3,105.44 180.67,105.07 C714.2 ; v2(196.19,63.2) 196.42,63.2 196.75,63.53 PR172.2 ; CN22.4 175.4,155.12 C647.2 C651.2 ; C712.1 194.22,108.44 v2(194.59,108.81) ; C715.1 192.56,105.23 v2(192.69,105.36) ; R558.1 174.64,90.47 v2(174.53,90.35) ; Q7030.1 v2(38.38,178.11) ; PR162.2 110.51,94.27 v2(110.65,94.4) ; R578.2 168.43,78.64 v2(168.44,78.66) ; PC183.1 198.25,66.8 197.55,66.1 197.55,64.71 198.17,64.08 v5(198.19,64.07) ; EC80.2 197.93,18.86 v2(197.81,18.97) ; v2(197.25,158.51) 197,158.26 CN22.50 ; R545.2 171.83,94.92 171.83,94.89 v2(171.6,94.67) ; R31.1 56.6,178.36 v2(56.98,178.74) ; v2(163.97,114.89) 163.97,114.37 C710.1 ; v2(193.01,101.27) 192.95,101.2 C717.2 ; v2(190.54,155.5) 190.6,155.56 CN22.34 ; v2(111.73,91.95) 111.86,91.82 112.73,91.82 R555.1 ; PC211.1 v2(39.27,47.04) ; v2(185.51,96.16) 185.51,95.82 185.79,95.54 C720.1 ; v2(171.73,92.79) 172.2,92.79 C297.1 ; C768.2 20.73,51.04 v2(21.23,50.54) C772.1 ; v2(187.4,158.7) CN22.26
  BOTTOM w0.508: C770.2 16.91,50.85 15.12,50.85 ; EC2.2 v2(32.29,178.35) ; PC5.1 v2(33.92,178.22) ; v2(86.66,50.83) 86.45,50.61 CN26.50 ; EC18.2 EC17.2 180.06,152.76 C653.1 ; v2(79.78,50.98) 80.05,50.71 CN26.34 ; v2(174.77,155.12) 174.82,155.07 C647.2 ; v2(81.08,56.12) 81.25,56.29 CN26.37 ; CN26.9 66.85,58.6 67.41,59.15 68.17,59.15 v2(68.58,59.56) ; v5(111.15,98.4) 111.44,98.4 PC168.1 ; PC46.1 30.27,175.37 v2(29.78,174.89) ; CN26.27 77.25,58.74 v2(77.62,59.11) ; CN26.26 76.85,50.75 v2(76.93,50.83) ; R580.1 v2(119.66,77.52) ; v2(19.96,59.23) 19.33,58.6 VC4.1 C760.2 C758.1 ; C37.1 52.1,178.99 v2(52.47,178.61) ; C699.1 161.44,117.78 v2(162.08,117.15) 162.71,117.78 C700.1 ; EC66.2 92.23,8.4 86.55,8.4 v2(86,7.85) ; PC198.1 57.53,51.79 57.59,51.73 57.59,51.19 57.55,51.15 v2(57.55,51.07) ; PC172.1 101.92,85.4 v2(101.88,85.4) ; FAN1.3 136.17,122.59 v2(135.62,123.14) ; v2(69.85,178.74) 70,178.74 70.28,178.46 EC1.1 ; PR179.2 PC209.1 56.93,47.68 v2(56.67,47.42) ; JDIM1.208 176,56.1 v2(173.87,56.1) ; PC216.1 45.12,44.79 v2(45.08,44.76) ; v2(72.9,50.5) 72.97,50.57 73.29,50.57 73.65,50.22 CN26.18 ; v2(195.18,159.13) 194,159.13 193,158.13 CN22.40 ; R543.2 123.72,94.79 123.47,95.05 v2(123.47,95.68) 123.72,95.94 R537.2 ; JDIM1.207 v2(111.45,52.76) ; v2(83.46,59.11) 83.65,58.92 CN26.43 ; v2(82.01,50.88) 82.45,50.44 CN26.40 ; v2(177.7,124.57) v2(177.7,125.21) ; v2(185.01,116.92) 186.65,116.92 C229.1 ; C763.2 19.33,57.58 v2(19.45,57.46) ; CN26.4 v2(64.85,47.98) ; CN26.21 74.85,58.96 74.65,59.16 v2(74.34,59.16) ; R439.1 v2(20.34,177.6) ; EC75.2 195.13,103.56 v2(195.41,103.84) ; v2(21.23,174.93) 20.15,174.93 C608.1 20.03,175.95 v2(21.23,175.95) ; CN22.18 183.44,157.84 v2(183.44,158.04) ; U2.2 v2(54.61,180.65) ; v2(64.52,178.66) 64.46,178.55 C8777.2 C8778.2 ; PC45.1 28.76,175.13 v2(29.01,174.89) ; v2(203.1,12.62) EC82.2 ; v2(63.65,181.28) 63.65,180.65 63.9,180.39 C48.2 64.29,180.42 v2(64.29,181.28) ; v2(69.37,59.02) 69.25,58.9 CN26.15 ; v2(63.02,181.28) 63.02,181.91 PR143.2 ; CN26.29 v2(78.05,56.17) ; C649.2 v2(191.57,152.21) ; CN26.35 v2(80.45,56.15) ; C230.1 v2(185.01,117.98)
  vias: v1(12.96,72.5) v1(14.22,38.29) v1(15.41,69.75) v1(16.07,49.38) v1(18.47,34.58) v1(21.99,39.83) v1(26.39,33.72) v1(28,10.82) v1(30.69,185.35) v1(34.93,185.75) v1(35.3,151.57) v1(46.81,180.82) v1(47.78,56.44) v1(50.21,19.36) v1(50.32,25.91) v1(52.68,13.36) v1(63.65,9.96) v1(72.6,7.24) v1(78.36,6.31) v1(84.54,174.09) v1(84.67,170.81) v1(88.69,7.48) v1(98.62,95.67) v1(106.38,5.63) v1(114.21,96.7) v1(129.03,112.5) v1(129.24,120.27) v1(134.47,178.05) v1(141.12,113.84) v1(145.11,178.11) v1(156.28,169.76) v1(156.29,53.1) v1(157.38,174.17) v1(159.96,48.78) v1(161.01,183.74) v1(162.09,177.87) v1(162.62,119.77) v1(162.62,39.9) v1(162.96,168.83) v1(166.39,166.91) v1(178.52,146.68) v1(190.27,63.41) v1(190.52,134.31) v1(191.68,66.97) v1(192.69,7.92) v1(194.42,76.09) v1(196.37,92.58) v1(198.17,111.51) v2(3.47,70.08) v2(3.56,35.87) v2(3.71,33.45) v2(3.71,9.96) v2(3.83,52.88) v2(3.83,51.49) v2(3.83,8.31) v2(3.85,68.61) v2(4.47,6.78) v2(4.83,71.24) v2(4.95,89.01) v2(5.39,89.49) v2(5.36,10.47) v2(5.87,32.44) v2(6.12,70.03) v2(6.07,34.39) v2(6.25,30.4) v2(6.25,27.86) v2(6.25,25.32) v2(6.25,22.78) v2(6.25,20.24) v2(6.25,17.7) v2(6.25,15.16) v2(6.25,12.62) v2(6.59,71.28) v2(6.84,89.49) v2(7.01,9.32) v2(7.8,68.82) v2(8.18,89.49) v2(8.15,53.01) v2(8.15,51.36) v2(8.15,33.33) v2(8.15,30.79) v2(8.15,28.25) v2(8.15,25.71) v2(8.15,23.17) v2(8.15,20.63) v2(8.15,18.09) v2(8.15,15.55) v2(8.15,13.01) v2(8.31,70.85) v2(8.53,35.68) v2(9.6,71.7) v2(9.56,29.36) v2(9.55,26.82) v2(9.55,24.28) v2(9.55,21.74) v2(9.55,19.2) v2(9.55,16.66) v2(9.55,14.12) v2(9.55,11.58) v2(9.8,69.77) v2(9.8,31.93) v2(9.8,9.07) v2(9.93,74.73) v2(10.03,89.3) v2(10.06,68.69) v2(11.33,51.36) v2(11.45,176.96) v2(11.45,53.01) v2(11.71,8.05) v2(12.01,89.47) v2(12.42,69.06) v2(12.47,70.92) v2(12.9,157.79) v2(12.9,34.29) v2(13.21,156.31) v2(13.23,52.25) v2(13.31,154.43) v2(13.31,152.15) v2(13.31,149.86) v2(13.31,147.57) v2(13.31,145.03) v2(13.31,142.75) v2(13.31,140.46) v2(13.31,137.92) v2(13.31,135.64) v2(13.31,132.72) v2(13.31,130.05) v2(13.31,127.89) v2(13.31,125.86) v2(13.31,123.57) v2(13.31,120.78) v2(13.31,118.36) v2(13.31,115.95) v2(13.31,113.28) v2(13.31,110.74) v2(13.31,108.08) v2(13.31,105.66) v2(13.31,103) v2(13.31,100.58) v2(13.31,97.79) v2(13.31,95.38) v2(13.28,92.02) v2(13.74,55.42) v2(13.65,49.2) v2(13.87,66.47) v2(14.3,71.22) v2(15.11,80.49) v2(15.14,78.41) v2(15.14,52.25) v2(15.26,96.06) v2(15.71,38.36) v2(15.9,105.33) v2(15.9,102.54) v2(16.04,37.75) v2(16.07,38.89) v2(16.28,117.3) v2(16.43,156.54) v2(16.43,153.95) v2(16.41,143.18) v2(16.41,139.24) v2(16.41,136.83) v2(16.43,132.92) v2(16.38,115.82) v2(16.46,163.6) v2(16.64,106.53) v2(16.81,117.7) v2(16.84,115.37) v2(16.79,97.59) v2(17.04,103.81) v2(17.22,150.85) v2(17.17,100.25) v2(17.3,19.99) v2(17.4,106.53) v2(18.06,179.25) v2(18.16,106.5) v2(18.29,148.29) v2(18.26,146.23) v2(18.44,105.33) v2(18.57,150.83) v2(18.61,38.67) v2(18.62,37.98) v2(18.73,37) v2(18.92,106.5) v2(19.13,37.6) v2(19.45,37.06) v2(19.58,103.81) v2(19.58,19.99) v2(19.58,17.45) v2(19.58,14.91) v2(19.66,73.56) v2(19.71,12.37) v2(19.76,106.5) v2(19.84,8.18) v2(20.85,10.21) v2(21.66,179.22) v2(21.87,118.03) v2(21.87,116) v2(21.99,20.12) v2(21.99,17.58) v2(21.99,15.04) v2(21.99,12.37) v2(22.25,42.98) v2(22.38,8.18) v2(22.68,78.79) v2(22.66,74.7) v2(22.66,73.63) v2(22.88,117.02) v2(23.14,57.07) v2(23.21,55.02) v2(23.26,99.24) v2(23.32,78.82) v2(23.26,74.22) v2(23.39,10.21) v2(23.52,81.25) v2(23.9,118.03) v2(23.9,116) v2(23.87,74.7) v2(23.87,73.69) v2(24.03,78.79) v2(24.66,17.45) v2(24.66,14.91) v2(24.66,12.37) v2(24.79,179.25) v2(24.92,8.18) v2(25.02,85.22) v2(25.07,86.39) v2(25.17,112.19) v2(25.16,111.56) v2(25.55,80.7) v2(25.93,75.36) v2(25.93,10.21) v2(25.88,7.16) v2(26.31,96.32) v2(27.2,188.52) v2(27.2,185.6) v2(27.18,180.59) v2(27.33,182.42) v2(27.46,12.5) v2(27.89,84.05) v2(27.91,82.42) v2(27.96,143.33) v2(27.96,139.24) v2(27.96,136.93) v2(27.95,132.82) v2(28.09,164.16) v2(28.09,160.35) v2(28.09,157.79) v2(28.09,154.05) v2(28.14,80.98) v2(28.85,115.49) v2(28.85,8.56) v2(28.98,188.52) v2(29.18,92.74) v2(29.18,91.54) v2(29.23,83.54) v2(29.28,86.21) v2(29.28,84.79) v2(29.31,82.14) v2(29.61,10.21) v2(29.77,123.19) v2(29.77,121.69) v2(29.84,89.94) v2(29.82,87.73) v2(30,80.19) v2(30.12,76.81) v2(30.38,120.83) v2(30.35,78.89) v2(30.38,7.29) v2(30.5,5.89) v2(31.01,117.71) v2(31.01,115.58) v2(31.39,8.56) v2(31.52,17.7) v2(32.03,188.52) v2(32.51,30.66) v2(32.92,7.29) v2(32.92,5.89) v2(34.82,188.65) v2(35.46,5.89) v2(36.47,187.5) v2(36.73,185.73) v2(37.36,153.59) v2(37.36,152.07) v2(37.87,53.14) v2(38.38,5.89) v2(38.63,8.92) v2(39.19,9.73) v2(39.52,52.25) v2(39.52,51.61) v2(39.9,52.76) v2(40.16,51.61) v2(40.16,10.19) v2(40.28,52.25) v2(40.79,51.61) v2(40.79,7.93) v2(40.79,6.02) v2(40.91,62.92) v2(41.43,9.32) v2(42.39,45.69) v2(43.46,9.96) v2(43.97,182.68) v2(44.6,171.88) v2(44.6,171.25) v2(44.73,52.38) v2(44.73,51.74) v2(45.36,52.38) v2(45.36,51.74) v2(46,52.38) v2(46,51.74) v2(46,9.96) v2(46.42,62.93) v2(46.89,179.63) v2(46.89,178.99) v2(47.27,49.84) v2(47.52,179.63) v2(47.52,178.99) v2(47.93,49.84) v2(47.9,49.2) v2(48.54,9.96) v2(48.56,49.84) v2(48.56,49.2) v2(49.2,49.84) v2(49.2,49.2) v2(49.83,49.84) v2(49.83,49.2) v2(50.14,170.66) v2(50.47,49.84) v2(50.47,49.2) v2(51.1,170.46) v2(51.1,49.84) v2(51.1,49.2) v2(51.08,9.96) v2(51.2,169.1) v2(51.69,50.6) v2(52.63,94.29) v2(52.6,50.6) v2(53.39,169.1) v2(53.47,50.6) v2(53.62,9.96) v2(53.67,57.05) v2(55.45,175.31) v2(56.16,9.96) v2(57.96,175.65) v2(58.52,23.98) v2(58.7,24.89) v2(58.7,9.96) v2(59.43,24.84) v2(59.71,24) v2(60.03,59.08) v2(60.48,8.81) v2(60.73,68.73) v2(61.31,171.45) v2(61.49,19.1) v2(61.49,18.21) v2(61.49,17.32) v2(62.38,19.1) v2(62.38,18.21) v2(62.38,17.32) v2(62.71,178.66) v2(62.94,171.45) v2(63.27,19.1) v2(63.27,18.21) v2(63.27,17.32) v2(64.04,66.4) v2(64.13,68.42) v2(64.54,171.37) v2(65.3,170.31) v2(66.26,92.44) v2(66.7,41.96) v2(66.7,39.93) v2(66.7,31.8) v2(66.7,29.9) v2(67.59,163.75) v2(67.59,162.48) v2(68.22,3.48) v2(69.11,185.6) v2(69.34,173.3) v2(69.65,81.59) v2(69.87,187.25) v2(70.31,81.59) v2(70.76,3.48) v2(72.92,187.25) v2(73.3,86.47) v2(73.3,3.48) v2(73.94,86.47) v2(74.09,174.19) v2(74.6,86.47) v2(75.11,166.8) v2(75.16,165.23) v2(75.16,164.16) v2(75.16,162.61) v2(75.31,187.22) v2(77.24,187.12) v2(78.43,3.48) v2(78.76,186.61) v2(79.14,183.95) v2(81.08,3.56) v2(81.43,183.21) v2(82.19,42.6) v2(83.28,61.48) v2(83.46,3.48) v2(83.59,41.33) v2(84.22,183.82) v2(84.22,41.33) v2(84.25,63.36) v2(84.25,26.7) v2(84.35,5) v2(84.68,61.37) v2(84.86,186.49) v2(86,3.48) v2(86.26,187.25) v2(86.38,70.66) v2(86.38,69.14) v2(86.89,5) v2(87.15,69.9) v2(87.6,62.81) v2(87.91,70.54) v2(87.91,69.14) v2(88.42,187.25) v2(88.42,30.4) v2(88.54,3.48) v2(89.05,62.76) v2(89.3,30.4) v2(89.43,5) v2(89.46,59.64) v2(89.46,59) v2(89.61,50.17) v2(89.61,49.45) v2(90.57,89.08) v2(90.7,187.25) v2(90.68,73.27) v2(90.75,38.84) v2(91.11,38.3) v2(91.08,5) v2(91.08,3.48) v2(91.46,38.84) v2(92.07,73.66) v2(93.62,3.48) v2(94.26,5) v2(94.64,187.88) v2(95.05,59.13) v2(95.1,190.98) v2(95.07,58.5) v2(95.65,191.95) v2(96.16,3.48) v2(97.23,40.28) v2(97.23,39.04) v2(97.86,39.68) v2(98.5,40.28) v2(98.5,39.04) v2(100.23,32.79) v2(100.86,32.79) v2(102.49,105) v2(103.29,106.48) v2(103.47,109.3) v2(103.47,107.82) v2(104.16,191.82) v2(104.42,167.56) v2(104.42,166.8) v2(104.6,104.98) v2(104.67,26.72) v2(104.67,25.65) v2(104.7,23.8) v2(105.18,187.38) v2(105.18,167.56) v2(105.18,166.8) v2(105.36,106.5) v2(105.54,109.19) v2(105.53,107.85) v2(105.81,189.66) v2(105.94,167.56) v2(105.94,166.8) v2(106.32,3.48) v2(106.45,157.15) v2(106.45,152.07) v2(106.45,146.99) v2(106.45,141.91) v2(106.83,191.82) v2(107.21,187.38) v2(107.67,17.6) v2(108.33,17.6) v2(108.86,3.48) v2(110.77,37.9) v2(110.77,36.88) v2(111.15,35.61) v2(111.4,3.48) v2(111.53,166.55) v2(111.53,157.15) v2(111.53,152.07) v2(111.53,146.99) v2(111.53,141.91) v2(111.53,136.83) v2(111.91,14.1) v2(112.8,166.55) v2(113.05,82.49) v2(113.05,81.86) v2(113.21,24.64) v2(113.41,45.24) v2(113.38,41.66) v2(113.54,38) v2(113.54,37.33) v2(113.82,14.07) v2(113.94,3.48) v2(114.07,166.55) v2(114.15,31.83) v2(114.6,43.59) v2(114.6,40.86) v2(114.58,27.48) v2(114.88,37.03) v2(114.88,36.27) v2(115.11,24.64) v2(115.23,186.26) v2(115.34,166.55) v2(115.97,187) v2(116,27.53) v2(116.32,51.06) v2(116.32,50.29) v2(116.32,49.53) v2(116.25,45.44) v2(116.34,36.85) v2(116.25,24.64) v2(116.36,36.12) v2(116.48,187.63) v2(116.48,3.48) v2(116.61,166.55) v2(116.61,157.15) v2(116.61,152.07) v2(116.61,146.99) v2(116.61,141.91) v2(116.61,136.83) v2(116.64,41.83) v2(116.74,191.82) v2(117.12,188.65) v2(117.09,187.27) v2(117.14,176.48) v2(117.3,126.77) v2(117.5,190.17) v2(117.58,28.32) v2(117.73,36.97) v2(117.68,24.64) v2(117.75,36.25) v2(117.88,166.55) v2(118.24,127.28) v2(119.02,191.95) v2(119.02,45.21) v2(119.02,24.64) v2(119.02,3.48) v2(119.15,175.44) v2(119.15,174.68) v2(119.15,166.55) v2(119.25,28.24) v2(119.45,41.58) v2(119.91,175.44) v2(119.91,174.68) v2(120.02,50.5) v2(120.02,49.86) v2(120.02,49.17) v2(120.42,166.55) v2(120.45,24.64) v2(120.6,32.29) v2(120.6,29.53) v2(120.67,175.44) v2(120.67,174.68) v2(120.78,46.03) v2(120.78,43.31) v2(121.31,191.95) v2(121.56,3.48) v2(121.69,166.55) v2(121.69,157.15) v2(121.69,152.07) v2(121.69,146.99) v2(121.69,141.91) v2(121.69,136.83) v2(121.97,177.7) v2(122.56,45.19) v2(122.56,41.71) v2(122.96,177.72) v2(122.96,166.55) v2(123.07,37.68) v2(123.07,36.8) v2(123.07,35.91) v2(123.34,180.26) v2(123.75,31.75) v2(124.1,3.48) v2(124.23,191.95) v2(124.23,166.55) v2(124.48,177.72) v2(124.61,45.31) v2(124.64,41.71) v2(124.59,28.21) v2(124.84,51.03) v2(124.84,50.14) v2(124.84,49.38) v2(125.1,37.81) v2(125.1,36.92) v2(125.1,36.03) v2(125.5,166.55) v2(125.84,88.93) v2(125.89,87.97) v2(126.01,177.72) v2(126.1,86.81) v2(126.44,50.88) v2(126.44,50.1) v2(126.44,49.4) v2(126.53,37.49) v2(126.53,36.68) v2(126.53,35.79) v2(126.51,32.79) v2(126.52,29.82) v2(126.62,46.23) v2(126.62,43.51) v2(126.62,41.81) v2(126.64,3.48) v2(126.77,166.55) v2(126.77,157.15) v2(126.77,152.07) v2(126.77,146.99) v2(126.77,141.91) v2(126.77,136.83) v2(127.1,84.89) v2(127.13,28.21) v2(127.66,191.87) v2(127.91,109.91) v2(127.89,31.51) v2(128.04,166.55) v2(128.32,90.82) v2(128.42,109.4) v2(128.62,37.6) v2(128.62,36.71) v2(128.62,35.82) v2(129.03,45.16) v2(129.01,41.94) v2(129.18,178.11) v2(129.18,3.48) v2(129.31,166.55) v2(129.41,125.83) v2(129.42,28.54) v2(129.82,77.98) v2(129.8,31.51) v2(130.07,178.11) v2(130.2,21.67) v2(130.33,45.53) v2(130.38,125.81) v2(130.52,79.18) v2(130.58,166.55) v2(130.96,178.11) v2(131.09,126.92) v2(131.13,37.85) v2(131.13,36.96) v2(131.13,36.14) v2(131.21,191.95) v2(131.2,30.04) v2(131.27,43.79) v2(131.27,41.08) v2(131.49,21.67) v2(131.62,28.58) v2(131.7,122.22) v2(131.72,3.48) v2(131.85,166.55) v2(131.85,157.15) v2(131.85,152.07) v2(131.85,146.99) v2(131.85,141.91) v2(131.85,136.83) v2(132.14,79.82) v2(132.23,125.22) v2(132.33,77.6) v2(132.29,49.09) v2(132.45,76.62) v2(132.62,45.36) v2(132.58,42.37) v2(132.85,31.51) v2(132.99,191.82) v2(132.99,190.81) v2(132.99,29.34) v2(132.99,21.67) v2(133.63,188.14) v2(133.57,37.85) v2(133.57,36.96) v2(133.57,36.07) v2(133.88,191.82) v2(133.88,190.81) v2(134.05,79.93) v2(134.05,78.66) v2(134.26,119.28) v2(134.26,3.48) v2(134.52,188.14) v2(134.77,191.82) v2(134.77,190.81) v2(134.95,123.16) v2(135.3,30.28) v2(135.45,40.74) v2(135.53,188.14) v2(135.66,191.82) v2(135.66,190.81) v2(135.7,78.63) v2(135.7,76.67) v2(135.7,75.91) v2(135.76,95.35) v2(135.86,113.21) v2(136.42,188.14) v2(136.4,95.35) v2(136.4,28.59) v2(136.55,191.82) v2(136.55,190.81) v2(136.5,113.18) v2(136.7,80.21) v2(136.7,78.92) v2(136.68,29.29) v2(136.8,3.48) v2(136.93,157.15) v2(136.93,152.07) v2(136.93,146.99) v2(136.93,141.91) v2(136.93,136.83) v2(136.93,131.75) v2(137.13,113.18) v2(137.16,28.21) v2(137.31,99.75) v2(137.31,97.5) v2(137.77,113.18) v2(137.9,31.04) v2(137.91,28.66) v2(137.99,80.54) v2(138,41.88) v2(139.09,191.82) v2(139.34,3.48) v2(139.61,81.9) v2(139.62,79.92) v2(139.59,41.73) v2(139.73,32.07) v2(139.7,28.35) v2(140.41,125.12) v2(140.41,123.95) v2(140.99,77.14) v2(140.99,76.51) v2(140.99,75.74) v2(141.46,28.46) v2(141.76,191.95) v2(141.88,3.48) v2(142.01,157.15) v2(142.01,152.07) v2(142.01,146.99) v2(142.01,141.91) v2(142.01,136.83) v2(142.01,131.75) v2(142.08,107.86) v2(142.18,41.89) v2(142.26,113.16) v2(142.26,112.52) v2(142.34,109.83) v2(142.32,31.46) v2(142.63,81.64) v2(142.77,117.78) v2(143.16,3.71) v2(143.33,92) v2(143.3,28.26) v2(143.48,32.14) v2(143.91,191.95) v2(143.94,21.67) v2(144.04,117.91) v2(144.04,100.33) v2(144.04,99.7) v2(144.02,97.49) v2(143.97,91.97) v2(144.2,43.51) v2(144.2,42.06) v2(144.42,3.48) v2(144.6,91.97) v2(144.58,31.55) v2(144.58,21.67) v2(144.95,29.93) v2(145.26,92) v2(145.29,76.61) v2(145.29,75.13) v2(145.82,191.95) v2(145.92,91.97) v2(145.96,81.29) v2(146.09,27.9) v2(146.3,43.55) v2(146.31,40.86) v2(146.56,91.97) v2(146.61,76.66) v2(146.61,75.13) v2(146.73,31.54) v2(146.96,3.48) v2(147.09,157.15) v2(147.09,152.07) v2(147.09,146.99) v2(147.09,141.91) v2(147.09,136.83) v2(147.09,131.75) v2(147.09,126.67) v2(147.12,28.99) v2(147.47,81.18) v2(147.85,191.95) v2(148.16,109.58) v2(148.26,106.79) v2(148.65,108) v2(148.96,30.42) v2(149.29,109.99) v2(149.34,32.07) v2(149.43,29.27) v2(149.35,3.45) v2(149.53,21.64) v2(149.59,80.17) v2(149.61,77.14) v2(149.63,41.67) v2(149.76,191.95) v2(150.16,21.64) v2(150.39,187.25) v2(150.54,109.95) v2(150.81,79.28) v2(151.03,189.28) v2(151.06,100.75) v2(151.19,99.09) v2(151.7,100.75) v2(152.04,191.95) v2(152.17,157.15) v2(152.17,152.07) v2(152.17,146.99) v2(152.17,141.91) v2(152.17,136.83) v2(152.17,131.75) v2(152.17,126.67) v2(152.21,80.12) v2(152.33,100.72) v2(152.33,75.13) v2(153.03,107.9) v2(153.22,45.01) v2(153.33,78.14) v2(153.44,189.15) v2(153.39,31.51) v2(153.51,41.83) v2(153.55,80.98) v2(153.87,37.74) v2(153.87,36.85) v2(153.87,35.96) v2(154.07,191.95) v2(154.07,182.3) v2(154.05,28.49) v2(154.13,24.64) v2(154.33,51.23) v2(154.33,50.34) v2(154.33,49.45) v2(154.58,189.15) v2(154.58,188.27) v2(154.96,75.93) v2(155.09,182.3) v2(155.28,78.95) v2(155.29,77.56) v2(155.3,43.51) v2(155.5,32.08) v2(155.52,29.31) v2(155.73,189.15) v2(155.73,188.27) v2(155.86,75.02) v2(155.98,182.3) v2(155.98,181.53) v2(156.02,37.76) v2(156.02,36.87) v2(156.02,35.98) v2(156.23,41.86) v2(156.47,28.26) v2(156.6,80.73) v2(156.55,45.25) v2(156.74,188.27) v2(157.25,157.15) v2(157.25,152.07) v2(157.25,146.99) v2(157.25,141.91) v2(157.25,136.83) v2(157.25,131.75) v2(157.22,120.8) v2(157.29,51.07) v2(157.29,50.19) v2(157.29,49.3) v2(157.36,31.77) v2(157.45,75.33) v2(157.63,188.27) v2(157.73,121.72) v2(157.72,79.16) v2(158.01,182.3) v2(158.01,181.66) v2(157.97,37.74) v2(157.97,36.85) v2(157.97,35.96) v2(158.16,41.97) v2(158.39,107.37) v2(158.37,28.46) v2(158.52,188.27) v2(158.6,45.53) v2(158.82,76.13) v2(159.41,191.82) v2(159.41,190.93) v2(159.41,190.04) v2(159.41,189.15) v2(159.41,188.27) v2(159.36,120.88) v2(159.39,32.07) v2(159.54,27.56) v2(159.92,182.42) v2(160.04,120.88) v2(160.02,37.74) v2(160.02,36.85) v2(160.02,35.96) v2(160.09,40.93) v2(160.16,43.64) v2(160.3,191.82) v2(160.3,190.93) v2(160.3,190.04) v2(160.3,189.15) v2(160.3,188.27) v2(161.11,27.51) v2(161.16,191.85) v2(161.16,190.96) v2(161.16,190.07) v2(161.16,189.18) v2(161.16,188.29) v2(161.16,31.95) v2(161.33,45.19) v2(161.33,41.7) v2(161.53,121.34) v2(161.57,182.55) v2(161.57,181.92) v2(162,74.49) v2(162.16,121.34) v2(162.18,28.34) v2(162.33,152.07) v2(162.33,146.99) v2(162.33,141.91) v2(162.33,136.83) v2(162.45,74.04) v2(162.74,50.67) v2(162.74,50.04) v2(162.74,49.4) v2(162.8,121.34) v2(162.86,37.74) v2(162.86,36.85) v2(162.86,35.96) v2(163.49,31.79) v2(163.54,30.13) v2(163.58,28.34) v2(163.83,132.39) v2(163.83,131.75) v2(164.15,111.41) v2(164.36,109.14) v2(164.46,132.39) v2(164.46,131.75) v2(164.48,44.93) v2(164.46,37.74) v2(164.46,36.85) v2(164.46,35.96) v2(164.64,41.61) v2(164.56,30.2) v2(165.6,32.16) v2(165.78,45.7) v2(165.76,42.98) v2(165.89,41.57) v2(166.01,183.06) v2(166.01,182.17) v2(166.01,181.28) v2(166.01,180.39) v2(166.58,50.75) v2(166.58,49.99) v2(166.58,49.23) v2(166.55,37.74) v2(166.55,36.85) v2(166.55,35.96) v2(167.28,183.29) v2(167.59,32.03) v2(168.2,50.75) v2(168.2,49.99) v2(168.2,49.23) v2(168.23,45.02) v2(168.23,41.86) v2(168.23,37.74) v2(168.23,36.85) v2(168.23,35.96) v2(168.68,132.64) v2(168.93,183.31) v2(168.93,180.77) v2(168.93,178.23) v2(168.93,175.69) v2(168.93,173.15) v2(168.93,170.61) v2(168.93,168.07) v2(168.93,165.63) v2(168.93,164.14) v2(168.98,29.36) v2(169.34,32.08) v2(169.44,162.36) v2(169.39,160.55) v2(170.1,30.3) v2(170.31,50.75) v2(170.31,49.99) v2(170.31,49.23) v2(170.28,44.21) v2(170.31,41.52) v2(170.27,37.74) v2(170.27,36.85) v2(170.27,35.96) v2(171.68,30.15) v2(172.11,164.01) v2(172.06,45.52) v2(172.06,41.58) v2(172.06,38.02) v2(172.16,31.45) v2(172.64,162.48) v2(173.61,58.98) v2(173.66,40.95) v2(174.72,153.75) v2(174.98,61.98) v2(175.17,36.12) v2(175.41,73.46) v2(175.66,60.35) v2(175.79,164.01) v2(176.3,58.93) v2(177.89,15.43) v2(179.09,124.64) v2(179.25,69.77) v2(179.25,69.14) v2(179.47,164.01) v2(179.86,124.64) v2(180.43,40.51) v2(180.43,39.88) v2(180.43,39.24) v2(180.43,38.61) v2(181.41,23.09) v2(181.86,23.55) v2(182.6,162.97) v2(182.62,13.56) v2(182.6,10.85) v2(183.53,31.79) v2(183.53,31.16) v2(184.41,28.68) v2(184.42,28.04) v2(184.43,15.01) v2(184.43,13.61) v2(184.53,56.52) v2(184.48,10.8) v2(184.68,164.01) v2(184.94,115.82) v2(185.06,59.28) v2(185.7,59.28) v2(186.03,15.01) v2(186.28,13.61) v2(186.36,10.87) v2(187.07,111.07) v2(187.22,164.01) v2(187.6,111.43) v2(188.24,119.19) v2(188.5,25.18) v2(188.5,24.55) v2(188.87,109.53) v2(189.76,164.01) v2(190.54,154.46) v2(191.29,82.3) v2(192.12,41.81) v2(192.23,42.44) v2(192.3,164.01) v2(192.76,41.83) v2(192.86,42.47) v2(193.17,34.04) v2(194.59,79.88) v2(194.84,164.01) v2(195.1,93.29) v2(195.1,92.66) v2(195.1,84.89) v2(196.24,59.61) v2(196.24,58.98) v2(196.4,47.31) v2(196.38,46.64) v2(196.49,40.82) v2(196.49,38.79) v2(196.49,35.76) v2(197.38,164.01) v2(198.6,129.92) v2(199.03,125.02) v2(199.03,124.38) v2(199.06,162.38) v2(199.1,59.58) v2(199.16,118.59) v2(199.16,117.96) v2(200.51,163.96) v2(200.51,158.88) v2(200.51,156.34) v2(201.45,69.65) v2(202.33,103.4) v2(202.33,100.86) v2(202.33,98.32) v2(202.33,95.78) v2(202.33,93.24) v2(202.33,90.7) v2(202.33,88.16) v2(202.33,85.62) v2(203.15,60.17) v2(204.87,60) v2(204.87,57.46) v2(204.87,54.92) v2(204.87,52.38) v2(204.87,49.84) v2(204.87,47.3) v2(204.87,44.76) v2(204.87,42.22) v2(204.87,39.68) v2(204.87,37.14) v2(204.87,34.6) v2(204.87,32.06) v2(204.87,29.52) v2(204.87,26.98) v2(204.87,24.44) v2(204.87,21.9) v2(204.87,19.36) v2(204.87,16.82) v2(204.87,14.28) v2(204.87,11.74) v5(29.49,55.04) v5(29.49,54.28) v5(29.49,50.09) v5(30.35,55.09) v5(32.21,49.96) v5(32.21,49.2) v5(32.21,48.44) v5(42.57,37.77) v5(42.57,37.01) v5(43.33,37.77) v5(43.33,37.01) v5(45.5,37.77) v5(45.49,37.01) v5(48.14,36.7) v5(48.16,38.23) v5(48.16,37.47) v5(48.92,38.23) v5(48.92,37.47) v5(48.92,36.7) v5(51.71,37.77) v5(51.71,37.01) v5(54.25,36.37) v5(55.14,36.37) v5(56.03,36.37) v5(56.79,36.37) v5(91.46,42.72) v5(92.1,42.16) v5(92.89,42.09) v5(97.46,55.14) v5(97.46,54.38) v5(98.22,55.14) v5(98.22,54.38) v5(98.58,93.65) v5(98.58,92.89) v5(99.01,55.14) v5(99.01,54.38) v5(99.08,94.29) v5(99.34,92.89) v5(99.34,92.13) v5(99.46,94.92) v5(99.46,93.65) v5(99.85,95.56) v5(99.85,94.29) v5(99.77,55.14) v5(99.77,54.38) v5(100.23,96.19) v5(100.23,94.92) v5(100.23,93.65) v5(100.51,55.14) v5(100.61,96.83) v5(100.61,95.56) v5(100.61,94.29) v5(100.56,52.1) v5(100.99,97.46) v5(100.99,96.19) v5(100.99,94.92) v5(100.99,93.65) v5(101.27,55.14) v5(101.32,52.1) v5(101.32,51.33) v5(101.32,50.57) v5(101.37,98.1) v5(101.37,96.83) v5(101.37,95.56) v5(101.37,94.29) v5(101.75,98.73) v5(101.75,97.46) v5(101.75,96.19) v5(101.75,94.92) v5(101.75,93.65) v5(102.13,98.1) v5(102.13,96.83) v5(102.13,95.56) v5(102.13,94.29) v5(102.51,98.73) v5(102.51,97.46) v5(102.51,96.19) v5(102.51,94.92) v5(102.51,93.65) v5(102.89,98.1) v5(102.89,96.83) v5(102.89,95.56) v5(102.89,94.29) v5(103.25,40.08) v5(103.3,97.46) v5(103.4,96.19) v5(103.94,39.14) v5(103.94,38.38) v5(103.91,37.62) v5(103.99,39.93) v5(104.72,39.93) v5(104.7,39.14) v5(104.7,38.38) v5(104.67,37.62) v5(104.97,183.4) v5(105.46,182.75) v5(105.8,183.81) v5(106.27,182.8) v5(106.54,183.5) v5(107.06,182.75) v5(111.15,99.16) v5(111.15,97.64) v5(113.56,99.19) v5(113.56,98.45) v5(113.56,97.71) v5(115.64,96.19) v5(116.18,96.75) v5(118.77,112.95) v5(119.28,113.59) v5(172.11,146.74) v5(172.11,145.97) v5(172.11,145.21) v5(172.87,146.74) v5(172.87,145.97) v5(172.87,145.21) v5(172.87,144.48) v5(172.87,143.74) v5(172.87,143) v5(172.87,142.24) v5(172.87,141.45) v5(172.87,140.64) v5(172.87,139.88) v5(173.63,146.74) v5(173.63,145.97) v5(173.63,145.21) v5(173.63,144.45) v5(173.63,143.69) v5(173.63,142.93) v5(173.63,142.16) v5(173.63,141.4) v5(173.63,140.64) v5(173.63,139.88) v5(174.29,140.23) v5(175.54,143.69) v5(175.54,142.93) v5(176.07,144.2) v5(176.51,143.33) v5(176.81,145.59) v5(176.81,144.83) v5(176.81,144.07) v5(177.54,145.59) v5(177.54,144.83) v5(177.54,144.07) v5(178.28,145.59) v5(178.28,144.78) v5(184.1,80.89) v5(184.1,80.15) v5(184.1,79.42) v5(184.1,78.68) v5(184.86,80.84) v5(184.86,80.1) v5(184.86,79.37) v5(184.86,78.63) v5(189.76,66.98) v5(189.76,66.22) v5(190.36,67.52) v5(190.4,65.58) v5(190.52,66.35) v5(190.9,68.05) v5(190.9,66.98) v5(196.54,32.66) v5(200.43,145.85) v5(200.43,145.09) v5(200.43,144.32) v5(200.43,143.56) v5(200.43,142.8) v5(200.43,132) v5(200.43,131.24) v5(200.43,130.48) v5(200.43,129.72) v5(200.43,128.96) v5(200.43,128.19) v5(200.43,127.43) v5(200.43,126.67) v5(200.43,125.91) v5(200.43,125.15) v5(200.43,124.38) v5(200.43,123.62) v5(200.43,120.32) v5(200.43,119.56) v5(200.43,118.8) v5(200.43,118.03) v5(200.43,117.27) v5(200.43,116.51) v5(200.43,115.75) v5(200.43,112.45) v5(200.43,111.68) v5(200.43,110.92)
