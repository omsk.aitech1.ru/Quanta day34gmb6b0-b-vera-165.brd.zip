# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVCC2: length 7
  TOP w0.381: R354.2 R353.2 184.5,33.29 v2(184.09,33.71)
  BOTTOM w0.381: v2(184.09,33.71) 184.17,33.79 v1(184.17,35.87) 184.17,38.12 v2(183.63,38.66)
  vias: v2(183.79,48.49) v2(183.79,47.85) v2(192.05,47.55) v2(192.05,46.91)
VCC_SENSE: length 50.7
  TOP w0.254: v2(97.95,75.59) 98.5,76.13 98.5,76.48 98.27,76.71 97.78,76.71 97.32,76.24 PR101.2
  BOTTOM w0.254: U25.E63 129.26,102.84 128,102.84 127.82,103.02 123.04,103.02 122.78,102.77 122.78,102.26 122.53,102.01 122.23,102.01 R501.1 121.95,101.99 121.74,101.78 120.19,101.78 118.13,99.72 118.13,97.13 117.98,96.98 117.98,91.88 107.05,80.95 v1(105.81,80.95) 105.31,80.95 99.79,75.44 98.1,75.44 v2(97.95,75.59)
VCCST_PWRGD_XDP: length 4
  TOP w0.127: CN8.50 76.06,65.65 75.34,64.93 R289.2 75.34,64.19 74.83,63.68 v1(74.57,63.68)
VSS_SENSE: length 50.7
  TOP w0.254: PR100.2 96.51,76.24 v2(97.19,75.57)
  BOTTOM w0.229: U25.E62 129.55,102.45 128.58,102.45
  BOTTOM w0.254: 128.58,102.45 127.85,102.45 127.66,102.64 123.71,102.64 R508.1 121.44,101.4 120.35,101.4 118.51,99.57 118.51,96.97 118.36,96.82 118.36,91.72 106.2,79.55 v1(105.43,79.55) 104.54,79.55 100.05,75.06 97.7,75.06 v2(97.19,75.57)
1P35V_BOOT: length 4.3
  TOP w0.203: PU7.18 97.86,41.99 97.66,42.19 97.66,42.24 97.36,42.54 97.36,42.95
  TOP w0.508: PR119.2 96.29,44.37 v1(97.05,43.61) 97.36,43.31 97.36,42.95
1P35V_CS: length 3.5
  TOP w0.127: PR122.2 101.82,40.34 v1(101.52,40.64) 100.56,39.68 PU7.13
1P35V_FB: length 7.2
  TOP w0.203: PU7.6 97.06,37.38 v1(96.09,36.4)
  TOP w0.254: v1(96.09,36.4) 95.73,36.75 93.62,36.75 92.73,35.87 92.61,35.87 92.61,34.72
1P35V_LGATE:
  vias: v1(99.34,50.98) v5(99.52,52.58) v5(99.59,53.31)
1P35V_PHASE: length 6.8
  TOP w0.127: 98.66,42.04 98.66,42.1
  TOP w0.203: PU7.16 98.66,42.04
  TOP w0.254: 98.66,42.1 98.66,43.1
  TOP w0.508: PC90.2 95.99,45.64 v5(96.19,45.44) 97,45.44 v1(97.69,44.76) 98.66,43.78 98.66,43.1
1P35V_S5: length 4.3
  TOP w0.127: PC114.1 98.06,35.62 v1(97.56,36.12)
  TOP w0.203: PU7.8 97.86,36.42 v1(97.56,36.12) ; PR130.2 PC114.1
1P35V_TON: length 4.7
  TOP w0.203: PR131.1 100.1,35.35 100.1,36.23 v1(99.69,36.63) 99.58,36.74 98.79,36.74 98.26,37.27 PU7.9
1P35V_UGATE: length 14.7
  TOP w0.203: v2(98.12,42.77) 98.12,42.63 98.26,42.49 PU7.17
  BOTTOM w0.508: 92.86,49.33 91.97,48.44 91.97,43.23 92.43,42.77 95.91,42.77 96.29,43.15 97.74,43.15 v2(98.12,42.77)
1P35V_VDDQ: length 38.4
  TOP w0.203: 95.7,38.66 95.91,38.87 PU7.5
  TOP w0.254: 95.7,38.66 95.7,37.85 v2(95.15,37.31) 94.98,37.14 93.37,37.14 92.73,36.5 92.1,36.5 91.83,36.23 PR128.2 91.44,35.87 v2(91.18,36.12)
  IN1 w0.254: v2(91.18,36.12) 92.23,37.16 92.23,39.8 94.13,41.71 103.66,41.71 v2(105.56,43.61)
  BOTTOM w0.254: v2(105.56,43.61) 105.69,43.74 105.69,46.91 107.08,48.31 107.08,52.25 105.18,54.15 PR189.1
1P35V_VID: length 3.1
  TOP w0.203: PR127.1 101.06,37.29 v1(100.63,37.72) 100.02,38.33 99.67,38.33 99.46,38.53 PU7.11
3D_CAM_EN: length 291.8
  TOP w0.127: v2(133.73,127.33) 128.95,132.11 112.39,132.11 83.13,161.37 76.11,161.37 75.86,161.62 55.09,161.62 54.28,160.8 54,160.53 53.71,160.53 52.23,159.06 48.51,159.06 44.98,155.52 v1(44.17,155.52) v2(42.87,155.52) 42.62,155.78 PQ42.2 ; v2(51.96,62.61) 51.96,62.46 R8558.2 ; v2(182.42,122.45) 182.42,115.9 184.48,113.84 184.48,108.43 186.71,106.2 R8561.1
  IN1 w0.14: v2(133.73,127.33) 140.41,127.33 143.48,124.26 159.89,124.26 161.69,122.45 v2(166.39,122.45)
  IN2 w0.14: v2(42.87,155.52) 42.87,154.98 35.8,147.9 35.8,115.15 40.14,110.81 40.68,110.27 40.68,103.67 43.22,101.13 43.22,93 43.6,92.62 43.6,86.68 42.81,85.89 40.36,85.89 39.15,84.68 39.15,73.88 38.49,73.22 38.49,71.62 40.43,69.67 42.47,69.67 43.15,68.99 45.79,68.99 48.23,66.55 49.96,66.55 51.53,64.97 51.53,63.37 51.96,62.95 v2(51.96,62.61) ; v2(166.39,122.45) v2(182.42,122.45)
3D_FW_GPIO: length 170.3
  TOP w0.127: v2(69.21,178.74) 69.35,178.61 CN2.8 ; v2(180.31,146.81) v1(181.94,145.19) 181.94,115.93 184.12,113.74 184.12,108.41 185.44,107.09 R8562.1
  IN2 w0.14: v2(158.01,158.62) 98.37,158.62 88.16,168.83 88.16,172.64 84.97,175.84 82.1,175.84 79.91,178.03 69.92,178.03 69.66,178.29 69.21,178.74 v2(69.21,178.74)
  BOTTOM w0.127: v2(180.31,146.81) 179.63,147.5 169.34,147.5 158.22,158.62 v2(158.01,158.62)
1237BSTPCH: length 2.9
  BOTTOM w0.254: v2(192.71,71.43) 192.71,71.17 193.17,70.71 PU10.20
  BOTTOM w0.508: PR165.2 192.3,72.13 192.71,71.72 v2(192.71,71.43)
1237BSTPCH_S: length 2.9
  BOTTOM w0.127: PR165.1 192.3,74.07 193.01,74.78 v1(193.09,74.78)
  BOTTOM w0.508: PC180.1 191.93,73.21 192.3,73.58 PR165.1
1237ENPCH: length 6.1
  BOTTOM w0.127: PU10.2 196.28,68.7 196.42,68.55 196.85,68.55 v2(197.33,68.07) 197.53,67.88 PC183.2 198.46,67.88 198.81,67.53 198.81,66.31 PR169.2
1237FBPCH: length 5.4
  BOTTOM w0.254: PR171.1 PR172.1 197.1,64.93 197.1,66.68 v1(197.15,66.73) 196.68,67.2 PU10.5
1237FBPCH_S: length 18.9
  TOP w0.127: v2(188.11,75.62) v1(188.11,74.47) 188.11,66.9 191.97,63.04 v2(193.11,63.04)
  BOTTOM w0.127: v2(193.11,63.04) 194.98,63.04 PR171.2 ; PR170.1 v2(188.11,75.62)
1237PFMPCH: length 1.4
  BOTTOM w0.127: PU10.3 196.16,68.2 196.26,68.09 PR167.1
1237PGPCH: length 2.7
  BOTTOM w0.127: PU10.1 196.18,69.2 196.37,69.01 PR166.2 196.86,69.48 v2(196.46,69.89)
1237SSPCH: length 2.5
  BOTTOM w0.127: v2(195.43,70.97) 195.1,71.29 PC182.1
  BOTTOM w0.254: PC182.1 194.67,71.21 PU10.23
8008LX1.5V:
  vias: v1(185.95,66.47)
51216S3: length 23.4
  TOP w0.127: R382.2 107.81,32.02 107.5,32.02 107.47,32.06 v1(107.29,32.06) 107.25,32.02 106.82,32.02 v2(106.58,32.26)
  TOP w0.203: v2(93.85,36.25) 93.8,36.19 93.8,35.63 PR129.2 94.22,35.62 94.26,35.66 95.08,35.66 PC113.1 96.2,35.62 97.46,36.89 PU7.7
  IN1 w0.14: v2(106.58,32.26) 96.98,32.26 95.55,33.68 95.3,33.68 93.85,35.13 v2(93.85,36.25)
81101_BST:
  vias: v1(96.42,86.92)
81101_HG: length 3.3
  TOP w0.127: 95.4,88.2 95.4,88.51 95.06,88.85 95.06,90.25 v2(94.93,90.38)
  TOP w0.203: PU3.9 94.42,86.73 94.61,86.92
81101_HG_G: length 17.4
  TOP w0.127: v2(95.78,90.42) 95.91,90.55 v1(95.91,91.24)
  TOP w0.508: PR70.2 v2(95.78,90.42)
  IN1 w0.508: v5(109.42,93.7) 108.58,94.54 106.45,94.54 104.52,92.61 v5(103.91,92.61) 102.72,91.41 97.14,91.41 96.15,90.42 v2(95.78,90.42)
81101_LG: length 17.9
  TOP w0.203: 93.11,87.05 93.22,86.94 PU3.12
  TOP w1.016: v5(103.66,100.25) v5(102.64,100.25) 100.1,100.25 v1(95.65,95.81) 93.24,93.4 93.24,89.84
  vias: v5(103.53,93.85) v5(104.14,94.31)
81101_PH: length 24.1
  TOP w0.203: PU3.10 94.02,87.32 94.26,87.55
  TOP w0.508: PC51.2 97.05,90.37 v2(97.1,90.42) 97.1,91.19 96.29,92 94.88,92 94.27,91.39 94.27,89.19 v1(94.29,89.18) 94.51,88.95 94.51,87.81 94.26,87.55
  IN1 w0.508: v2(97.1,90.42) 97.1,90.48 97.41,90.78 104.6,90.78 106.75,92.94 v5(106.75,93.78)
  BOTTOM w0.508: PR161.2 110.54,99.97 v5(110.01,100.51)
  vias: v5(106.2,101.27) v5(106.2,100.51) v5(106.96,101.27) v5(106.96,100.51) v5(107.72,101.27) v5(107.72,100.51) v5(108.48,101.27) v5(108.48,100.51) v5(109.24,101.27) v5(109.24,100.51) v5(110.01,101.27)
81101COM: length 5.7
  TOP w0.203: PU3.23 92.82,81.27
  TOP w0.254: 92.82,81.27 92.82,80.78 92.23,80.19 v1(91.01,80.19) 90.31,79.49 PC58.2 90.31,78.16 PR98.2
81101DIFFOUT: length 6.5
  TOP w0.127: PR95.1 93.61,79.05 93.75,78.92 93.75,77.67 v1(94.18,77.24)
  TOP w0.203: PU3.25 93.62,80.77
  TOP w0.254: 93.62,80.77 93.62,80.19 93.24,79.81 PR95.1 PR94.1
81101FB: length 9.9
  TOP w0.127: v1(92.23,74.98) 92.11,75.1 PR99.1
  TOP w0.203: PU3.24 93.22,81.08
  TOP w0.254: PR99.1 92.34,76.36 PC63.2 92.34,78.16 PR94.2 91.99,78.04 PC62.1 91.09,78.16 PC58.1 91.6,79.68 92.35,79.68 93.22,80.55 93.22,81.08
81101ILIM: length 3.5
  TOP w0.127: v1(89.3,81.2) 89.31,81.21 PR92.2
  TOP w0.203: PU3.21 91.03,82.8
  TOP w0.254: 91.03,82.8 90.45,82.22 PR92.2
81101IOUT: length 4.4
  TOP w0.203: v2(90.42,82.96) 90.57,82.96 90.82,83.2 PU3.20
  BOTTOM w0.127: v1(90.07,81.46) PR88.2
  BOTTOM w0.381: PR88.2 PC56.1 90.9,82.47 v2(90.42,82.96)
81101ROSC: length 3.6
  TOP w0.203: PU3.22 92.42,81.22 v2(91.97,80.77)
  BOTTOM w0.127: v1(91.34,80.32) 91.51,80.32 v2(91.97,80.77)
  BOTTOM w0.381: PR93.2 92.95,80.77 v2(91.97,80.77)
81181_AGND: length 0.6
  TOP w0.381: PC53.1 v2(88.29,85.4)
  vias: v1(93.5,84) v2(92.61,85.01) v2(92.61,84) v2(92.61,82.98) v2(93.62,85.01) v2(93.62,82.98) v2(94.64,85.01) v2(94.64,84) v2(94.64,82.98)
+AUDIO_5V_AVDD: length 5
  TOP w0.127: L42.1 156.62,13.37 v1(156.41,13.16)
  TOP w0.305: U21.9 159.04,14 C598.1
  TOP w0.508: L42.1 156.74,14.27 C599.1 C598.1
+AUDIO_5V_VDD: length 24.8
  TOP w0.203: 162.37,10.88 162.14,10.88 161.97,10.72 U21.3
  TOP w0.381: 162.37,10.88 163.13,10.88 163.73,11.48 C568.1 164.27,11.98 164.6,11.65 164.6,11.63 165.38,10.85 R418.1 165.88,10.73 165.99,10.62 ; 165.99,10.62 166.1,10.73 R7481.2 ; 165.99,10.62 166.01,10.59 166.01,9.65 165.94,9.58 v2(165.94,9.53)
  BOTTOM w0.508: v2(151.18,9.4) 151.31,9.53 152.37,9.53 153.21,10.36 155.7,10.36 156.44,11.1 v2(156.61,11.1) 157.12,10.59 157.12,10.21 158.44,8.89 163.75,8.89 164.56,9.7 165.76,9.7 v2(165.94,9.53)
  vias: v1(146.84,7.7)
+BATCHG: length 1.9
  TOP w0.508: PR7.1 119.6,181.36 v2(119.4,181.36)
  vias: v1(109.5,183.13) v1(112.76,182.79) v1(117.01,181.11)
+G_SEN_PW: length 22.9
  TOP w0.254: U13.8 188.17,58.46 ; C390.1 184.7,55.82 185.06,56.18 U13.1 ; U13.14 183.97,57.9 C395.1
  TOP w0.508: 188.17,58.46 189.24,58.46 189.73,57.97 189.82,57.97 190.24,57.54 190.24,57.45 190.47,57.23 190.47,57.18 191.16,56.49 191.16,55.27 190.55,54.66 R301.2 189.9,54.41 189.45,53.96 187.67,53.96 ; 187.67,53.96 187.74,54.03 R299.2 ; 187.67,53.96 184.47,53.96 183.89,54.54 C390.1 183.4,55.82 182.88,56.34 v1(182.88,56.82) R308.2 C395.1
+PCH_VCCDSW: length 5.3
  TOP w0.381: C307.1 154.69,93.28 C309.2 155.59,92.13 v1(156.61,91.11) 156.98,90.74 v2(156.98,90.35)
  BOTTOM w0.254: U25.AG19 157.38,90.71 157.03,90.35 v2(156.98,90.35) 156.91,90.35 156.57,90.69 U25.AG20
+PRWSRC: length 0.6
  TOP w0.508: v2(90.78,185.5) 90.77,185.49 PR212.2
  vias: v1(83.45,175.25) v1(93.7,183.4) v1(95.73,183.4) v1(97,183.4) v2(84.21,176.29)
+SMDDR_VREF_DIMM: length 18.6
  TOP w0.508: R379.2 151.59,25.51 R380.2 152.25,27.33 v2(152.25,27.56) v1(152.25,31.67) 152.25,32.69 152.44,32.88 C515.1 152.44,34.7 C500.1 152.44,35.26 R370.1 152.52,36.25 v2(152.52,37.74) 152.54,37.76 C446.1 152.54,39.68 C436.1
  BOTTOM w0.254: v2(152.52,37.74) 152.25,38 JDIM1.126 ; JDIM2.126 v2(152.25,27.56)
+SMDDR_VREF_DQ0: length 9.5
  TOP w0.508: v4(112.06,32.78) 113.01,32.78 113.97,33.73 R350.2 114.8,34.08 C469.1 C470.1 R351.1 R352.2
  BOTTOM w0.381: JDIM2.1 112.35,33.07 v4(112.06,32.78)
+SMDDR_VREF_DQ1: length 1.8
  TOP w0.254: R319.2 R320.1 v2(110.63,46.79)
  vias: v1(107.85,38.79) v2(107.85,37.01) v2(107.85,35.61)
+VA: length 2.8
  BOTTOM w0.254: PR208.2 67.33,178 68.93,179.6 PD7.2
  vias: v1(72.52,178.44)
+VA_AC:
  vias: v1(35.76,177.52) v1(36.04,179.63) v1(37.26,181.34) v5(35.33,184.07) v5(35.33,183.31) v5(36.22,183.44) v5(36.22,182.55) v5(37.11,183.44) v5(37.11,182.55) v5(64.62,183.64) v5(65.58,183.64) v5(65.58,182.88) v5(66.32,183.64) v5(66.34,182.88) v5(66.5,182.07) v5(67.18,183.64) v5(67.23,182.63)
+VA_AIR: length 18.1
  TOP w0.127: v2(64.79,182.58) 65.81,181.56 67.49,181.56 68.17,182.25 76.79,182.25 PR216.1
  BOTTOM w0.127: PD7.1 65.96,179.6 65.56,180.01 v1(65.56,180.77) 65.56,181.64 PR144.1 64.79,182.41 v2(64.79,182.58)
+VAD: length 36.1
  TOP w0.254: v2(83.16,180.21) 83.16,180.47 83.69,181 PR16.1 ; v2(95.81,185.37) 96.28,184.9 v2(96.28,184.89) 96.37,184.8 97.55,184.8 98.07,184.28 PR11.1
  BOTTOM w0.254: PQ38.4 71.44,175.05 71.22,174.83 71.22,174.33 71.73,173.82 71.73,173.66 72.36,173.03 74.95,173.03 v1(75.54,173.61) 76.45,173.61 ; PC118.1 89.58,182.89 89.43,183.03 89.43,185.65 89.82,186.03 95.14,186.03 v2(95.81,185.37)
  BOTTOM w0.381: PD9.1 78.01,173.82 PC231.1
  BOTTOM w0.508: 80.81,180.54 82.83,180.54 v2(83.16,180.21) 83.64,180.7 83.64,181.2 85.37,182.93 88.42,182.93 89.38,181.97 PC118.1
A2_DE0: length 2.4
  TOP w0.127: R8519.1 59.01,167.57 v1(59.92,167.57) U8021.16
A2_DE1: length 3.4
  TOP w0.127: R8513.1 59.21,165.02 59.23,165 v1(59.94,165) 60.5,165.56 60.5,166.4 60.67,166.57 U8021.18
A2_EQ0: length 2.6
  TOP w0.127: R8518.1 59.82,166.22 v1(59.89,166.29) 60.67,167.07 U8021.17
A2_EQ1: length 2.5
  TOP w0.127: U8021.15 59.39,168.07 R8512.1
A_DE0: length 2.4
  TOP w0.127: U15.16 192.76,29.13 v1(192.94,28.96) 193.27,28.96 193.83,29.52 R359.1
A_DE1: length 4.3
  TOP w0.127: U15.18 192.84,30.13 v1(192.94,30.23) 195.66,30.23 R358.1
A_EQ0: length 3.3
  TOP w0.127: R357.1 194.9,29.97 193.63,29.97 193.28,29.63 U15.17
A_EQ1: length 3.9
  TOP w0.127: R362.1 195.15,28.31 192.81,28.31 192.49,28.63 U15.15
AC_LED_ON#: length 54.4
  TOP w0.127: PQ18.2 47.8,95.78 45.72,97.87 45.72,98.6 45.08,99.24 PQ13.2 43.2,99.62 v1(41.93,100.89) 41.37,101.45 38.06,101.45 v2(37.65,101.04) ; U11.28 37.84,67.33 v2(38.62,68.12)
  BOTTOM w0.127: v2(37.65,101.04) 37.65,91.58 36.56,90.49 36.56,85.03 39.25,82.35 40.76,82.35 42.54,80.57 42.54,76.3 41.43,75.19 41.43,72.02 38.62,69.21 v2(38.62,68.12)
AC_PRESENT_EC: length 248.6
  TOP w0.127: v2(35.23,70.54) 34.84,70.15 R281.2
  IN1 w0.076: 167.28,83.36 167.18,83.46 167.18,86.26 166.04,87.4 166.04,88.16 165.62,88.58 165.25,88.58 165,88.84 165,89.13 164.41,89.71 163.94,89.71 v2(163.53,90.12)
  IN1 w0.14: 167.28,83.36 168.35,82.3 168.35,81.05 170.08,79.32 170.08,78.93 170.71,78.3 171.78,78.3 174.61,75.46 175.84,75.46 177.09,74.21 177.09,72.19 177.38,71.89 177.38,71.54 178.25,70.68 178.25,67.51 178.93,66.82 178.93,63.13 180.26,61.8 180.26,56.08 179.95,55.77 179.95,48.4 180.26,48.08 180.26,42.24 179.43,41.41 179.43,29.31 174.48,24.35 169.92,24.35 169.25,23.69 169.25,23.69 168.92,23.36 165.26,23.36 165.02,23.11 127.99,23.11 127.63,22.76 122.02,22.76 121.64,22.37 120.83,22.37 120.58,22.63 117.3,22.63 116.78,23.15 109.67,23.15 107.61,25.2 100.99,25.2 100.47,25.72 83.2,25.72 82.19,26.72 82.19,27.05 81.76,27.48 81.76,29.74 74.74,36.76 74.74,42.42 68.17,49 68.17,52.52 59.25,61.44 57.5,61.44 55.93,63.02 55.93,66.88 52.42,70.38 52.08,70.73 50.1,70.73 49.8,71.03 41.88,71.03 41.76,71.15 41.27,71.15 40.61,71.15 40.61,71.15 39.15,71.15 38.77,71.52 37.21,71.52 36.47,70.79 35.48,70.79 v2(35.23,70.54)
  BOTTOM w0.076: U25.AJ8 163.33,89.91 v2(163.53,90.12)
ACC_LED#: length 107.5
  TOP w0.127: v2(201.52,27.48) 201.52,25.93 200.34,24.75 CN14.20
  BOTTOM w0.127: U25.V1 170.71,95.3 171.02,95.61 172.68,95.61 R538.1 173.51,95.68 173.63,95.68 173.83,95.49 177.91,95.49 178.46,94.94 178.46,93.64 179.92,92.18 179.92,91.47 181.19,90.2 181.19,88.41 181.95,87.65 181.95,83.64 180.78,82.47 179.32,82.47 178.99,82.15 178.99,79.05 178.8,78.86 178.8,76.35 179.04,76.11 179.04,72.29 178.55,71.79 178.55,68.85 178.8,68.6 178.8,66.25 178.35,65.81 178.35,63.44 181.79,60.01 181.79,54.6 184.4,51.99 192.53,51.99 193.28,51.24 193.28,49.46 194.7,48.04 201.49,48.04 202.77,46.76 202.77,34.9 v1(201.7,33.83) 200.84,32.97 EC79.1 201.34,27.49 201.51,27.49 v2(201.52,27.48)
ACCEL_INTA#: length 50.2
  TOP w0.127: v1(182.27,60) 182.68,60.4 D10.2 184.15,60.4 184.3,60.25 184.3,59.87 v2(184.17,59.74)
  IN1 w0.127: 177.37,78.89 177.37,78.54 178.36,77.55
  IN1 w0.14: v2(173.73,92.67) 175.37,91.03 175.37,87.27 178.66,83.98 178.66,80.26 177.37,78.97 177.37,78.89 ; 178.36,77.55 180.83,75.07 180.83,73.5 182.05,72.28 182.05,66.45 183.91,64.6 183.91,64.3 183.92,64.28 183.92,60 v2(184.17,59.74)
  BOTTOM w0.076: 168.43,94.36 168.14,94.36 168.03,94.26 166.87,94.26 U25.Y3
  BOTTOM w0.127: 168.43,94.36 169.24,94.36 169.85,93.75 169.95,93.75 170.43,93.27 172.5,93.27 C297.2 173.17,92.67 v2(173.73,92.67) 174.35,92.67 174.51,92.83 R552.1
ACCEL_INTA#_R: length 3.3
  TOP w0.127: v1(187.32,59.69) 186.61,60.4 D10.1 186.18,60.02 186.38,59.82 U13.11
ACIN: length 316.5
  TOP w0.127: PQ16.2 37.36,91.98 37.97,91.37 38.56,91.37 39.25,92.06 40.25,92.06 40.65,91.66 42.4,91.66 42.82,92.08 ; 42.82,92.08 43.51,91.38 v2(47.72,91.38) ; 42.82,92.08 PQ17.2 ; v2(105.45,122.28) 103.11,122.28 96.04,115.2 96.04,111.29 78.92,94.17 64.61,94.17 63.25,92.82 VC6.1 63.25,86.29 v1(58.44,81.48) 57.54,80.58 54.42,80.58 54.41,80.57 51.56,80.57 v2(51.13,81) 50.8,80.67 U11.97 ; v2(90.1,185.52) 89.89,185.52 89.49,185.12 PR218.1 PR217.1 89.49,183.3 89.96,182.83 PU1.5 ; v2(194.71,120.83) 189.33,120.83 v2(188.49,119.99)
  IN1 w0.14: v2(105.43,132.33) 104.49,132.33 104.29,132.13 102.92,132.13 102.46,132.59 102.46,140.42 80.54,162.33 80.54,169.82 78.79,171.58 78.79,174.9 88.59,184.71 89.29,184.71 v2(90.1,185.52)
  IN2 w0.14: v2(165.68,121.87) 165.15,121.34 163.85,121.34 162.86,122.33 161.42,122.33 158.58,125.17 150.19,125.17 147.08,122.06 137.5,122.06 135.84,123.72 129.13,123.72 127.34,121.93 117.34,121.93 113.87,118.47 109.88,118.47 106.07,122.28 v2(105.45,122.28) 105.45,132.32 v2(105.43,132.33)
  BOTTOM w0.127: v2(47.72,91.38) 47.72,87.55 50.44,84.84 50.44,81.69 v2(51.13,81) ; v2(194.71,120.83) 195.98,120.83 196.49,120.32 196.49,104.06 196.62,103.94 196.62,100.89 196.16,100.43 195.04,100.43 194.89,100.58 Q41.5 194.89,102.3 EC75.1 ; v2(188.49,119.99) 184.5,119.99 181.23,116.71 170.84,116.71 v2(165.68,121.87)
ACZ_BCLK: length 9.4
  BOTTOM w0.076: 163.35,82.14 162.75,82.74 162.75,83.24 U25.AW8
  BOTTOM w0.127: R591.2 165.85,76 164.77,77.08 164.77,78.58 v2(164.32,79.03) 163.35,80 163.35,82.14
ACZ_RST#: length 10.5
  BOTTOM w0.076: 163.31,79.67 163.09,79.89 163.09,82.12 162.58,82.63 162.58,83.31 162.63,83.36 162.63,83.67 162.86,83.89 163.24,83.89 163.42,84.07 163.42,84.51 163.09,84.84 U25.AU8
  BOTTOM w0.127: 163.31,79.67 163.79,79.19 163.79,78.95 164.54,78.21 164.54,76.31 R590.2
ACZ_RST#_AUDIO: length 101.3
  TOP w0.127: v2(173.05,58.68) 171.84,57.47 171.33,57.47 v1(170.71,56.85) 171.17,56.39 171.17,53.1 173.14,51.13 174.15,51.13 176.43,48.85 176.43,47.89 177.44,46.88 177.44,44.9 178.38,43.96 178.38,43.13 177.44,42.19 177.44,36.54 178.11,35.87 178.11,31 178.38,30.73 178.38,26.52 177.7,25.83 169.1,25.83 166.52,23.26 166.52,21.35 167.07,20.8 167.07,19.01 167.21,18.87 167.21,18.82 v2(167.26,18.77) ; v2(172.49,13.89) 172.9,13.49 172.9,10.41 172.49,10 172.49,9.58 172.36,9.45 Q29.1 173.2,8.56 173.58,8.94 174.88,8.94 175.26,9.32 C582.1 176.89,9.8 178.71,9.8 179.13,10.22 179.41,10.22 179.89,10.7 179.95,10.7 180.11,10.86 180.26,11.01 U20.11
  BOTTOM w0.127: v2(172.49,13.89) 172.49,14.01 170.93,15.57 170.17,15.57 167.26,18.48 v2(167.26,18.77) ; v2(173.05,58.68) 169.7,58.68 165.01,63.38 R590.1
ACZ_SDIN0: length 98.8
  TOP w0.127: v2(167.89,19.43) 167.89,21.06 167.31,21.64 167.31,22.97 169.41,25.07 178.03,25.07 179.15,26.18 179.15,31.05 178.87,31.32 178.87,36.24 178.2,36.91 178.2,41.83 179.17,42.8 179.17,44.3 178.23,45.24 178.23,47.93 177.28,48.88 177.28,49.07 174.46,51.89 173.46,51.89 171.93,53.42 171.93,55.88 v2(173.23,57.18) ; v2(175.31,13.77) 175.46,13.61 175.46,13.12 176.2,12.38 EC60.2 R410.1
  BOTTOM w0.127: v2(173.23,57.18) 173.49,57.45 173.49,57.97 173.23,58.23 169.61,58.23 164.11,63.73 164.11,75.24 163.76,75.58 163.76,76.37 164.27,76.88 164.27,78.15 163.57,78.86 163.57,79.09 162.84,79.82 162.84,82.07 162.29,82.61 U25.AY10 ; v2(175.31,13.77) 174.66,14.41 173.16,14.41 170.99,16.59 170.23,16.59 168.35,18.47 168.35,18.97 v2(167.89,19.43)
ACZ_SDOUT: length 10.4
  BOTTOM w0.076: 162.21,81.77 162.21,82.14 161.83,82.51 161.83,83.73 161.69,83.87 161.44,83.87 161.19,84.13 161.19,84.44 U25.AU11
  BOTTOM w0.127: 162.21,81.77 161.24,80.8 161.24,80.26 161.62,79.88 v1(161.62,79.05) 161.62,77.99 R581.2 162.19,77.41 R589.2
ACZ_SDOUT_AUDIO: length 92.4
  TOP w0.127: v2(168.81,18.77) 168.35,19.23 168.35,21.23 168.01,21.57 168.01,23.13 169.57,24.69 178.19,24.69 179.53,26.02 179.53,31.21 179.26,31.48 179.26,36.4 178.59,37.07 178.59,41.68 179.55,42.64 179.55,44.46 178.61,45.4 178.61,49.23 177.32,50.52 v1(177.32,51.23) 177.32,51.78 v2(177.56,52.02) ; v2(175.33,14.73) 175.64,14.43 175.67,14.43 176.01,14.09 176.01,13.22 176.2,13.03 176.71,13.03 EC61.2 177.78,14.1 180.12,14.1 180.21,14.01 U20.5
  BOTTOM w0.127: R589.1 162.97,74.88 163.35,74.5 163.35,63.42 174.14,52.63 176.43,52.63 177.04,52.02 v2(177.56,52.02) ; v2(175.33,14.73) 175.27,14.8 173.32,14.8 171.15,16.97 170.39,16.97 168.81,18.55 v2(168.81,18.77)
ACZ_SPKR: length 125.9
  TOP w0.127: Q31.2 175.13,5.61 174.5,4.98 174.14,4.98 173.09,6.03 173.09,6.82 172.39,7.52 171.99,7.52 171.6,7.91 171.6,9.25 172.11,9.75 172.11,10.16 172.52,10.57 172.52,13.21 v2(171.85,13.87)
  BOTTOM w0.076: 169.57,95.05 169.51,95.11 168.14,95.11 168.03,95 167.56,95 U25.V2
  BOTTOM w0.127: v2(171.85,13.87) 171.85,14.1 170.8,15.16 170.03,15.16 166.81,18.39 166.81,18.98 167.77,19.94 173.51,19.94 174.21,20.64 177.43,20.64 183.08,26.29 183.08,28.17 v1(183.67,28.75) 183.08,29.34 183.08,45.01 181.46,46.64 181.46,59.98 178.09,63.35 178.09,65.08 178.1,65.09 178.1,65.91 178.51,66.32 178.51,68.53 178.29,68.74 178.29,71.95 178.51,72.16 178.51,74.17 178.14,74.54 178.14,75.68 178.55,76.09 178.55,78.97 178.74,79.16 178.74,82.26 179.21,82.73 180.68,82.73 181.69,83.75 181.69,87.54 180.94,88.3 180.94,90.09 179.66,91.37 179.66,92.07 178.2,93.53 178.2,94.84 177.81,95.23 173.63,95.23 173.48,95.39 171.11,95.39 170.76,95.05 169.57,95.05
ACZ_SYNC: length 8
  BOTTOM w0.076: U25.AV11 161.61,84.19 162,83.8 162,82.6 162.61,81.99 162.61,81.56
  BOTTOM w0.127: 162.61,81.56 162.61,79.4 v2(163.02,78.98) 163.09,78.91 163.09,78.65 163.61,78.13 R574.2 R585.2
ACZ_SYNC_AUDIO: length 100.8
  TOP w0.127: v2(167.89,18.77) 167.45,19.22 167.45,20.96 166.93,21.48 166.93,23.12 169.25,25.45 177.86,25.45 178.77,26.36 178.77,30.89 178.49,31.16 178.49,36.08 177.82,36.76 177.82,42.03 178.77,42.97 178.77,44.14 177.85,45.06 177.85,47.02 176.81,48.06 176.81,49.01 174.3,51.51 173.3,51.51 171.55,53.26 171.55,56.26 v1(171.98,56.69) 171.98,56.72 v2(173.05,57.79) ; U20.10 180.44,11.51 179.86,10.93 179.79,10.93 179.31,10.45 179,10.45 178.58,10.03 176.74,10.03 176.42,10.35 176.42,10.43 ; 176.42,10.43 175.79,9.8 175.18,9.8 174.72,9.35 173.57,9.35 173.3,9.62 v2(173.3,13.92) ; 176.42,10.43 EC65.2
  BOTTOM w0.127: v2(173.3,13.92) 173.19,14.03 173,14.03 170.83,16.21 170.07,16.21 167.89,18.38 v2(167.89,18.77) ; R585.1 163.38,76.46 163.38,75.01 163.73,74.66 163.73,63.58 169.52,57.79 v2(173.05,57.79)
AD_AIR: length 163.5
  TOP w0.127: U11.69 53.93,67.33 55.17,66.09 PC66.1 56.22,65.64 59.24,65.64 60.07,66.47 v1(60.07,67.34) v2(60.07,68.05)
  BOTTOM w0.127: PR144.2 63.87,182.55 62.88,182.55 PR143.1 61.43,182.98 52.8,182.98 51.08,181.25 51.08,177.34 49.8,176.06 44.46,176.06 39.01,170.61 36.26,170.61 32.28,166.63 32.28,112.65 43.19,101.74 43.19,97.09 46.86,93.42 46.86,87.2 49.43,84.63 49.43,81.48 53.9,77.01 53.9,72.44 57.15,69.19 58.93,69.19 v2(60.07,68.05)
AD_ID: length 157.8
  TOP w0.127: v2(50.44,60.38) 52.3,58.52 57.73,58.52 v1(57.99,58.78) 58.16,58.95 58.16,59.89 57.94,60.12 C386.1 R298.2
  IN2 w0.14: v2(40.41,174.17) 40.41,174.1 39.97,173.66 39.97,165.98 39.02,165.03 39.02,164 42.31,160.71 42.31,154.79 35.53,148.01 35.53,115.04 40.41,110.16 40.41,103.56 42.95,101.02 42.95,92.89 43.33,92.51 43.33,86.79 42.7,86.16 40.25,86.16 38.89,84.79 38.89,73.99 37.44,72.54 37.44,70.59 40.28,67.74 40.28,67.36 41.17,66.47 43.08,66.47 43.97,65.58 43.97,64.69 46.32,62.34 48.47,62.34 v2(50.44,60.38)
  BOTTOM w0.127: CN20.5 31.01,179.8 31.01,177.98 31.51,177.48 EC2.1 32.02,176.96 33.55,176.96 34.31,176.2 37.74,176.2 39.01,174.93 39.65,174.93 v2(40.41,174.17)
AD_TYPE: length 10.2
  TOP w0.127: R294.1 56.55,62.75 56.81,63.01 56.84,63.01 57.29,63.46 57.5,63.46 58.19,64.14 D7.1 58.29,64.57 58.22,64.64 57.57,64.64 57.29,64.36 55.6,64.36 v1(54.63,65.33) 54.63,65.72 53.82,66.53 U11.67
ADAPTER_SEL_EC: length 4.8
  TOP w0.127: R279.2 R284.1 54.68,69.77 v2(54.3,69.39) 53.84,68.93 U11.73
ALERT#: length 5.8
  TOP w0.127: PU3.4 97.08,84 v1(97.38,84.3) 97.48,84.4 98.41,84.4 PR81.2 98.44,84.75 98.58,84.89 100.23,84.89 100.47,84.64 PR82.1
AMP_BEEP: length 2.5
  TOP w0.254: U20.12 180.83,9.83 180.49,9.49 v1(180.49,9.32) C584.2
AMP_BEEP_L: length 3.5
  TOP w0.254: C594.1 R427.2 C584.1 R433.1
AMP_BEEP_R2: length 1
  TOP w0.254: R427.1 C583.2
AMP_CLK: length 2.5
  BOTTOM w0.254: U28.8 197.02,17.2 197.54,16.68 197.54,16.01 R612.1
AMP_DAT: length 2
  BOTTOM w0.254: U28.7 197.04,17.7 198.01,16.73 R611.1
AMP_PD#_R: length 8.5
  BOTTOM w0.127: 200.52,14.81 R613.2 201.06,14.28 202.44,14.28 v1(202.59,14.43)
  BOTTOM w0.254: U28.6 197.1,18.2 198.1,17.2 198.98,17.2 199.62,16.56 D13.3 200.09,15.8 200.52,15.37 200.52,14.81
B2_DE0: length 2.4
  TOP w0.127: U8021.3 67.23,167.57 R8520.1
B2_DE1: length 2.7
  TOP w0.127: R8514.1 67.12,169.88 66.52,169.88 v1(66.32,169.67) 65.71,169.07 U8021.6
B2_EQ0: length 2.5
  TOP w0.127: U8021.2 66.33,167.07 v1(66.37,167.03) 66.85,166.55 R8516.1
B2_EQ1: length 2.7
  TOP w0.127: U8021.4 65.78,168.07 66.09,168.38 v1(66.22,168.38) 66.82,168.38 R8521.1
B_DE0: length 1.7
  TOP w0.127: U15.3 187.35,29.13 187.1,28.88 R360.1
B_DE1: length 1.9
  TOP w0.127: U15.6 187.25,27.63 R363.1
B_EQ0: length 1.7
  TOP w0.127: R356.1 186.96,29.9 187.22,29.63 U15.2
B_EQ1: length 1.9
  TOP w0.127: U15.4 187.23,28.63 R361.1
B_TEMP_MBAT: length 40.3
  TOP w0.127: BAT14.6 130.96,188.91 v1(130.96,188.01) PC1.2 PR4.2 PR3.1 128.29,188.14 v2(128.55,188.39) ; BAT17.9 152.95,187.99 151.53,189.41 151.53,189.96 BAT15.6
  IN1 w0.14: v2(128.55,188.39) 131.47,188.39 133.09,186.77 146.87,186.77 BAT15.6
BATDIS_G: length 4.8
  BOTTOM w0.254: PR22.2 92.89,180.42 91.84,179.38 90.14,179.38 PC119.2
BATDIS_ID_DOD: length 4.1
  BOTTOM w0.254: PR9.1 102.22,175.79 102.22,177.62 PC244.1 101.03,177.8 PQ39.4
BATSHIP: length 184.7
  TOP w0.127: v2(42.7,87.05) 44.87,84.87 44.87,81.12 44.4,80.65 U11.113 ; v2(117.32,183.36) 116.79,182.83 PQ1.2
  IN1 w0.14: v2(117.32,183.36) 109.65,183.36 107.47,185.55 101.6,185.55 101.18,185.12 97.99,185.12 97.01,186.1 89.48,186.1 84.1,180.73 63.61,180.73 62.08,179.2 58.49,179.2 58.19,179.5 56.28,179.5 54.38,177.6 52.98,177.6 46.12,170.74 41.55,170.74 40.46,169.65 40.46,167.74 33.03,160.31 33.03,156.17 35.28,153.92 35.28,114.56 35.61,114.23 v2(35.61,114.25)
  IN2 w0.14: v2(42.7,87.05) 42.62,87.12 42.62,100.33 40.03,102.92 40.03,109.83 v2(35.61,114.25)
BATT+:
  vias: v1(141.86,182.17)
BIOS_CS#: length 13.6
  TOP w0.127: R220.1 53.49,85.09 53.69,84.89 54.1,84.89 54.25,84.74 54.25,84.53 54.1,84.38 52.37,84.38 52.22,84.23 52.22,84.02 52.37,83.87 54.1,83.87 54.25,83.72 54.25,83.5 54.1,83.35 52.87,83.35 52,82.47 v1(51.59,82.47) 51.21,82.47 50.54,81.81 50.15,81.81 49.2,80.86 U11.101
BIOS_RD#: length 15.4
  TOP w0.127: R212.1 52.35,92.25 53.3,91.3 53.3,87.59 v1(52.22,86.51) 51.46,85.75 51.46,83.59 50.89,83.02 50.89,82.81 50.35,82.26 49.96,82.26 48.4,80.7 U11.103
BIOS_SPI_CLK: length 15.8
  TOP w0.127: R225.1 52.67,91.04 v1(52.67,89.71) 52.67,87.86 50.82,86.02 50.82,83.87 50.19,83.24 50.19,82.97 48.61,81.39 47.91,81.39 47.6,81.09 U11.105
BIOS_WP#: length 10.7
  BOTTOM w0.127: U23.3 186.21,111.66 183.76,109.21 180.41,109.21 R490.1 179.97,109.14 179.86,109.03 R491.1 179.37,109 TP25.1
BIOS_WR#: length 15
  TOP w0.127: R226.1 53.49,91.65 53.68,91.46 53.68,87.36 52.98,86.67 52.98,86.03 v1(52.09,85.14) 51.84,84.89 51.84,83.43 50.44,82.03 50.05,82.03 48.8,80.78 U11.102
BIT_CLK_AUDIO: length 86.5
  TOP w0.127: U20.6 180.45,13.51 179.87,12.93 178.91,12.93 EC62.2 178.4,13.44 177.79,13.44 177.15,12.8 176.1,12.8 175.74,13.16 175.74,13.94 175.49,14.2 174.34,14.2 172.83,15.71 172.83,16.37 173.72,17.26 174.41,17.26 175.08,17.93 176.32,17.93 177.18,18.79 177.18,23.28 177.82,23.93 178.51,23.93 180.29,25.71 180.29,31.52 180.02,31.79 180.02,36.87 179.35,37.54 179.35,41.36 180.31,42.33 180.31,44.77 179.37,45.71 179.37,51.31 177.8,52.88 v1(176.05,52.88) 173.54,52.88 172.69,53.73 172.69,55.56 174.33,57.2 174.33,58.88 173.75,59.46 v2(173.12,59.46)
  BOTTOM w0.127: R591.1 C741.2 168.29,64.3 v2(173.12,59.46)
BLON_CON: length 40.6
  TOP w0.127: CN2.23 61.85,178.44 63.97,180.56 64.4,180.56 64.74,180.91 64.74,181.46 62.63,183.57 47.09,183.57 43.05,179.53 43.05,176.89 44.12,175.82 44.12,173.94 v1(44.09,173.91) 43.11,172.93 D1.1 43.11,171.25 43.47,170.89 R6.1 C2.2
BOARD_ID0: length 21.3
  TOP w0.127: v2(179.17,93.92) 179.17,93.71 179.42,93.45 180.3,93.45 R174.2
  IN2 w0.076: 166.39,92.71 166.14,92.71 166.02,92.59 164.35,92.59 163.97,92.21 163.97,91.76 163.98,91.75
  IN2 w0.14: 166.39,92.71 167.97,92.71 168.21,92.47 170.81,92.47 171.85,91.43 175.19,91.43 176.67,92.91 178.16,92.91 v2(179.17,93.92) ; v2(164.29,91.07) 163.93,91.43 163.93,91.69 163.98,91.75
  BOTTOM w0.089: U25.AG6 164.63,90.73 v2(164.29,91.07)
  BOTTOM w0.127: R539.1 179.22,93.97 v2(179.17,93.92)
BOARD_ID1: length 16.9
  TOP w0.127: v3(169.7,86.58) 170.68,86.58 172.02,87.92 176.55,87.92 176.7,88.06 177.49,88.06 178.65,86.9 178.65,86.52 178.83,86.34 181.45,86.34 R205.2 R199.1
  BOTTOM w0.076: v3(169.7,86.58) 169.31,86.18 168.04,86.18 U25.AP1
BOARD_ID2: length 13.3
  IN2 w0.14: v2(166.28,88.93) 166.73,89.37 170.44,89.37 171.63,88.19 173.25,88.19 173.89,88.83 v3(173.89,90.39)
  BOTTOM w0.089: v2(166.28,88.93) 165.96,88.61 U25.AL4
  BOTTOM w0.127: v3(173.89,90.39) 173.93,90.39 174.79,91.25 R558.2 R559.1
BOARD_ID3: length 11.6
  TOP w0.127: v2(166.32,79.15) 166.32,76.94 165.89,76.51 165.89,76.24 R255.1 164.86,76.78 R248.2
  IN2 w0.14: v3(165.41,84.67) 165.41,83.78 165.71,83.49 165.71,79.76 v2(166.32,79.15)
  BOTTOM w0.127: v3(165.41,84.67) 165.01,85.07 U25.AT5
BOARD_ID4: length 21.2
  TOP w0.127: v2(180.94,93.89) 181.31,93.51 R175.2
  IN2 w0.076: v3(165,92.02) 165.4,92.43 166.16,92.43 166.17,92.44 166.33,92.44
  IN2 w0.14: 166.33,92.44 167.64,92.44 167.87,92.2 170.7,92.2 171.74,91.17 175.3,91.17 176.78,92.65 179.18,92.65 180.42,93.89 v2(180.94,93.89)
  BOTTOM w0.089: v3(165,92.02) 164.98,92.01 164.98,90.9 U25.AG5
  BOTTOM w0.127: v2(180.94,93.89) 180.24,94.58 R540.1
BOARD_ID5: length 30
  TOP w0.127: v1(187.12,95.56) 186.51,96.16 v2(186.18,96.16) 186.21,96.2 R167.2
  IN2 w0.14: v2(186.18,96.16) 185.7,96.64 184.67,96.64 183.85,95.82 183.85,95.62 182.61,94.37 178.8,94.37 177.61,93.18 176.56,93.18 175.08,91.7 171.96,91.7 170.92,92.74 168.32,92.74 168.08,92.97 166.15,92.97 165.7,93.43 165.26,93.43 v2(164.83,92.99)
  BOTTOM w0.076: U25.AB6 164.63,93.44 164.83,93.24 v2(164.83,92.99)
  BOTTOM w0.127: R549.1 186.54,93.86 186.54,95.81 v2(186.18,96.16)
BOARD_ID6: length 27.8
  TOP w0.127: R161.2 R164.1 186.15,101.48 186.15,100.33 182.74,96.91 178.54,96.91 178.4,96.78 174.91,96.78 174.56,97.13 173.4,97.13 171.86,95.59 171,95.59 170.57,95.16 v2(168.91,95.16) 168.17,95.16 167.11,94.11 166.62,94.11 165.49,92.99 v2(165.45,92.99)
  BOTTOM w0.076: v2(165.45,92.99) 165.45,92.98 165.28,92.81 U25.AD5
BOARD_ID7: length 14.5
  TOP w0.127: R204.2 179.08,87.17 R198.1 177.94,88.32 176.17,88.32 v1(176.05,88.44) 175.77,88.17 171.92,88.17 170.77,87.02 169.51,87.02 v2(169.07,86.58)
  BOTTOM w0.076: v2(169.07,86.58) 168.67,86.97 168.25,86.97 168.04,86.76 167.13,86.76 166.88,87.02 U25.AN3
BOARD_ID8: length 29.4
  TOP w0.127: v2(164.18,92.99) 164.18,93.22 164.44,93.47 165.66,93.47 166.01,93.83 166.01,94.36 v1(166.09,94.44) 166.11,94.46 167.1,94.46 168.3,95.66 169.11,95.66 169.35,95.42 170.47,95.42 170.73,95.68 170.73,95.72 171.61,96.6 172.34,96.6 173.12,97.38 174.67,97.38 175.02,97.03 178.29,97.03 178.43,97.17 182.64,97.17 185.9,100.43 185.9,101.58 R163.1 R160.2
  BOTTOM w0.076: U25.AD7 163.98,92.79 v2(164.18,92.99)
BQACDRV: length 4.5
  TOP w0.127: PU1.4 90.46,182.97 v2(90.09,183.34)
  BOTTOM w0.254: v2(90.09,183.34) 91.49,183.34 v1(91.84,182.98) 92.31,182.52 92.31,182.5 PR22.1
BQACN: length 24.1
  TOP w0.127: v2(95.4,173.76) 95.2,173.96 94.84,173.96 94.51,174.29 94.51,175.16 95.19,175.84 97,175.84 98.74,177.58 98.74,184.44 98.03,185.15 96.87,185.15 96.21,185.81 95.14,185.81 v1(95.06,185.74) 94.97,185.64 94.93,185.64 PC9.1 93.23,183.95 PC240.2 91.96,183.12 PU1.1
  BOTTOM w0.127: PR222.1 95.78,173.91 95.55,173.91 v2(95.4,173.76)
BQACP: length 25.3
  TOP w0.127: v2(95.4,174.4) 95.22,174.22 94.94,174.22 94.77,174.4 94.77,175.06 95.3,175.59 97.11,175.59 98.99,177.48 98.99,184.55 98.13,185.41 96.97,185.41 96.12,186.26 94.65,186.26 94.46,186.07 v1(93.75,186.07) PC7.2 92.77,184.71 PC240.1 91.46,183.4 PU1.2
  BOTTOM w0.127: PR221.1 95.73,174.22 95.58,174.22 v2(95.4,174.4)
BQB_1:
  vias: v2(96.54,180.86)
BQB_2:
  vias: v2(93.72,179.71)
BQBATDRV: length 16.7
  TOP w0.305: v2(89.61,177.57) 89.61,177.99 89.96,178.34 PU1.11
  IN1 w0.508: v2(89.61,177.57) 89.61,176.63 89.89,176.35 99.46,176.35 v2(101.93,173.89)
  BOTTOM w0.254: PR9.2 101.9,173.91 v2(101.93,173.89)
BQCLK: length 4.4
  TOP w0.127: PR15.1 86.84,177.2 v2(87.59,177.95) 88.03,178.39 88.03,179.32 88.83,180.12 PU1.9
BQCMSRC: length 1.8
  TOP w0.127: PR212.1 90.77,183.52 90.96,183.34 PU1.3
BQDATA: length 5.8
  TOP w0.127: PR13.1 85.82,177.75 v2(86.04,177.96) 86.3,178.22 87.22,178.22 87.78,178.78 87.78,179.43 88.62,180.27 88.62,180.34 88.9,180.62 PU1.8
BQHIDRV: length 10.4
  IN1 w0.508: v5(93.9,180.59) 94.28,180.22 102.72,180.22 v2(103.73,181.23)
BQIOUT: length 3.8
  TOP w0.127: PU1.7 88.8,181.12 v2(88.01,180.33) 87.54,179.86 87.03,179.86 PC232.1 87.02,178.85 PR12.2
BQLODRV: length 12.9
  IN1 w0.508: v2(104.77,181) 103.18,179.4 93.29,179.4 v2(92.78,178.89)
BQLR:
  vias: v1(115.13,174.48)
BQPHASE: length 17.4
  TOP w0.508: v5(97.05,182.37) 96.5,181.82 95.25,181.82 94.8,181.37 PC234.2
  IN1 w0.508: v5(105.22,177.44) 106.17,178.4 106.17,180.85 105.02,182 103.56,182 102.41,180.85 98.57,180.85 v5(97.05,182.37)
  vias: v2(93.79,181.32) v2(107.02,176.72) v5(104.13,175.68) v5(104.19,176.48) v5(104.37,177.25) v5(105.03,176.63) v5(105.07,175.83)
BQSRN: length 1.9
  TOP w0.254: PR219.1 90.35,177.78 90.45,177.88 v2(90.45,177.99) 90.46,178 PU1.12
BQSRP: length 3
  TOP w0.127: PR220.1 v2(92.6,177.11)
  TOP w0.254: PR220.1 91.07,177.66 91.07,178.05 90.96,178.17 PU1.13
BQVCC: length 4.6
  TOP w0.254: PR11.2 95.78,183.52 95.51,183.25 95.51,182.88 v2(95.15,182.51) 94.88,182.25 PC13.1 93.7,182.25 93.07,181.62 PU1.20
BRIGHT: length 5
  TOP w0.127: v1(58.62,173) 58.66,172.96 R58.2 R27.2 ; R27.2 60.92,173.13 R28.1 ; R27.2 61.17,172.96 R440.1
BT_COMBO_EN#: length 99.1
  TOP w0.127: R94.2 175.99,158.86 v1(175.99,156.64) 175.99,156.46 175.45,155.93 172.79,155.93 172.54,155.68 v2(172.54,155.25)
  IN1 w0.14: v2(172.54,155.25) 168.2,150.9 168.2,131.09 169.94,129.34 169.94,121.04 v2(169.25,120.35)
  IN2 w0.14: v2(169.63,95.86) 169.63,97.86 170.9,99.14 170.9,100.34 171.33,100.76 171.65,100.76 172.15,100.27 172.89,100.27 173.5,100.88 175.33,100.88 177,99.21 178.7,99.21 v2(179.45,98.46) 179.88,98.03 180.18,98.03 180.52,97.7 182.36,97.7 182.84,98.17 182.84,98.76 182.46,99.13 182.46,103.33 182.94,103.8 182.94,106.37 180.08,109.23 180.08,114 173.74,120.35 v2(169.25,120.35)
  BOTTOM w0.076: v2(169.63,95.86) 169.27,95.51 168.12,95.51 168.03,95.59 167,95.59 166.93,95.67 166.31,95.67 U25.U4
  BOTTOM w0.127: R512.1 179.22,98.69 v2(179.45,98.46)
BT_OFF: length 98.1
  TOP w0.127: Q3.5 191.33,159.19 190.77,159.75 190.33,159.75 188.72,158.14 188.72,155.32 190.93,153.11 190.93,147.73 187.63,144.42 187.63,115.65 189.03,114.25 189.03,113.88 188.77,113.62 188.76,113.62 188.42,113.28 v1(188.42,112.45) 188.42,110.87 187.98,110.44 187.98,108.76 188.52,108.23 188.52,107.64 188.64,107.51 188.64,106.63 189.51,105.77 189.51,98.1 188.11,96.7 188.11,94.67 187.3,93.86 186.93,93.86 186.74,94.04 185.31,94.04 185.31,94.05 184.99,94.05 184.5,93.56 R180.1 184.11,93.07 183.56,92.53 182.31,92.53 182.09,92.32 178.93,92.32 178.92,92.32 175.53,92.32 174.35,91.14 172.69,91.14 171.11,89.56 170.12,89.56 169.56,89 169.56,88.07 v2(169.77,87.86)
  BOTTOM w0.076: U25.AM3 166.87,88.1 168.11,88.1 168.27,88.25 169.38,88.25 v2(169.77,87.86)
C_IN_CLK: length 5.8
  TOP w0.127: C327.2 21.98,83.98 21.82,84.14 21.46,84.14 v1(20.94,83.62) 20.42,84.14 19.98,84.14 19.84,84 R222.1 19.29,84.18 18.14,84.18 R219.2
C_IN_CLK#: length 5.9
  TOP w0.127: C324.2 21.98,84.51 21.83,84.37 21.46,84.37 v1(20.94,84.89) 20.42,84.37 19.98,84.37 19.84,84.51 R214.1 19.36,84.4 18.25,84.4 R215.2
C_TX0_HDMI+: length 17
  TOP w0.127: C343.2 18.54,79.31 17.43,79.31 R241.1 16.39,79.31 16.05,79.31 R234.1 15.5,79.31 15.02,79.31 v2(14.78,79.07)
  IN1 w0.14: v2(14.78,79.07) 14.53,79.32 14.01,79.32 13.87,79.18 13.87,76.06 13.1,75.29 11.29,75.29 10.85,75.73 10.85,78.99 10.76,79.09 10.64,79.09 CN24.7
C_TX0_HDMI-: length 17
  TOP w0.127: v2(14.78,79.83) 15.07,79.54 15.5,79.54 R234.2 16.05,79.54 16.39,79.54 R233.1 17.43,79.54 18.54,79.54 C339.2
  IN1 w0.14: v2(14.78,79.83) 14.53,79.58 13.9,79.58 13.61,79.29 13.61,76.17 12.99,75.56 11.4,75.56 11.12,75.84 11.12,79.1 10.87,79.35 10.6,79.35 CN24.9
C_TX1_HDMI+: length 12.4
  TOP w0.127: C336.2 18.54,81.6 17.43,81.6 R232.1 16.39,81.6 16.05,81.6 R231.1 15.5,81.6 15.03,81.6 v1(14.53,81.1) 14.53,81.48 14.39,81.62 14.08,81.62 13.97,81.52 13.97,78.44 13.12,77.59 12.18,77.59 CN24.4
C_TX1_HDMI-: length 12.4
  TOP w0.127: C331.2 18.54,81.83 17.43,81.83 R230.1 16.39,81.83 16.05,81.83 R231.2 15.5,81.83 15.08,81.83 v1(14.53,82.37) 14.53,82.02 14.36,81.85 13.98,81.85 13.74,81.61 13.74,78.53 13.02,77.81 12.19,77.81 CN24.6
C_TX2_HDMI+: length 11.9
  TOP w0.127: CN24.1 10.61,76.06 10.74,76.06 11.44,75.36 12.91,75.36 v1(13.43,74.84) 13.96,75.36 14.37,75.36 14.76,75.74 14.76,76.76 15.04,77.04 15.48,77.04 R247.1 16.06,77.04 16.37,77.04 R253.1 17.43,77.03 18.54,77.03 C354.2
C_TX2_HDMI-: length 11.9
  TOP w0.127: C349.2 18.54,77.25 17.43,77.25 R246.1 16.4,77.27 16.03,77.27 R247.2 15.51,77.27 14.94,77.27 14.53,76.85 14.53,75.84 14.28,75.59 13.96,75.59 v1(13.43,76.11) 12.91,75.59 11.53,75.59 10.84,76.29 10.66,76.29 CN24.3
C_TXC_HDMI+: length 9.6
  TOP w0.127: R219.1 16.59,84.26 16.05,84.26 R217.1 15.5,84.26 14.72,84.26 v1(14.17,83.72) 13.63,84.26 13.43,84.26 13.23,84.07 13.23,80.87 12.94,80.59 12.19,80.59 CN24.10
C_TXC_HDMI-: length 9.6
  TOP w0.127: CN24.12 12.18,80.81 12.85,80.81 13,80.97 13,84.16 13.33,84.49 13.68,84.49 v1(14.17,84.99) 14.67,84.49 15.5,84.49 R217.2 16.05,84.49 16.66,84.49 R215.1
CAP+: length 3.8
  TOP w0.254: U20.36 188.57,16.01 188.85,16.28 v1(189.2,16.28) 190.12,16.28 190.92,17.08 C562.2
CAP-: length 3.7
  TOP w0.254: U20.35 188.54,15.51 188.7,15.67 190.34,15.67 v2(190.57,15.91) 190.96,16.3 C562.1
CAPSLED#: length 81
  TOP w0.127: v2(35.76,18.87) 36.45,18.87 36.98,18.34 R397.2 ; U11.34 38.8,65.64 42.09,68.93 v2(42.09,69.17)
  IN1 w0.14: v2(42.09,69.17) 42.09,69.39 41.82,69.66 37.73,69.66 36.66,68.6 36.66,67.19 34.6,65.13 34.6,64.08 27.27,56.75 27.27,53.78 23.59,50.11 23.59,49.11 20.71,46.23 20.71,44.99 20.39,44.68 20.39,42.27 25.35,37.31 25.35,32.42 34,23.78 34,22.53 35.76,20.76 v2(35.76,18.87)
  BOTTOM w0.127: v2(35.76,18.87) 35.39,18.5 32.73,18.5 v1(32.5,18.27)
CAPSLED#_R: length 1.7
  TOP w0.127: R397.1 39.15,18.5 CN13.5
CATERR#: length 5.5
  BOTTOM w0.076: 128.7,100.1 128.72,100.12 129.69,100.12 129.75,100.18 130.02,100.18 130.33,99.87 U25.K61
  BOTTOM w0.127: 128.7,100.1 125.63,100.1 TP31.1
CFG0: length 86
  TOP w0.127: v2(69.87,65.33) 69.37,64.83 R288.1 69.37,63.89 v1(69.24,63.75)
  IN2 w0.14: v2(69.87,65.33) 69.87,67.04 69.5,67.41 69.5,68.64 69.64,68.78 69.64,70.06 70.12,70.55 70.95,70.55 71.19,70.3 71.19,69.7 71.73,69.16 74.21,69.16 74.46,69.41 76.39,69.41 82.51,75.53 89.5,75.53 90.09,76.12 98.07,76.12 98.83,75.36 99.66,75.36 100.73,76.44 101.68,76.44 108.19,82.94 108.19,86.68 110.79,89.27 111.59,89.27 115.04,92.73 115.04,93.24 115.48,93.68 116.05,93.68 118.54,96.16 125.86,96.16 125.91,96.11 128.42,96.11 130.01,94.51 130.91,94.51 131.59,93.84 v2(131.59,93.46)
  BOTTOM w0.127: U25.AC60 131.24,93.11 v2(131.59,93.46)
CFG1: length 78.5
  TOP w0.127: v2(69.95,68.45) 69.56,68.45 69.06,67.95 CN8.36
  IN2 w0.14: v3(126.68,93.55) 126.68,93.55 118.66,93.55 117.69,92.57 117.69,92.21 116.39,90.91 115.87,90.91 112.36,87.41 111.76,87.41 110.31,85.95 110.31,82.02 101.68,73.39 95.38,73.39 94.31,72.31 90.7,72.31 89.36,73.66 86.01,73.66 84.87,72.53 84.87,71.94 84.19,71.25 82.01,71.25 77.88,67.11 70.64,67.11 69.95,67.81 v2(69.95,68.45)
  BOTTOM w0.076: U25.AC62 129.62,92.77 127.49,92.77 127.15,93.1
  BOTTOM w0.127: v3(126.68,93.55) 126.68,93.57 127.15,93.1
CFG2: length 78.1
  TOP w0.127: CN8.38 70.06,65.87 v2(70.56,65.38) 70.51,65.33 v1(70.51,63.81)
  IN2 w0.14: v2(127.39,93.55) 126.97,93.13 126.07,93.13 125.93,93.27 118.92,93.27 118.01,92.35 118.01,92.15 116.5,90.65 115.98,90.65 112.47,87.14 111.88,87.14 110.58,85.84 110.58,81.9 101.78,73.1 95.47,73.1 94.41,72.03 90.47,72.03 89.11,73.39 86.12,73.39 85.14,72.42 85.14,71.83 84.3,70.98 82.12,70.98 77.99,66.85 72,66.85 70.56,65.4 v2(70.56,65.38)
  BOTTOM w0.076: U25.AC63 129.15,92.95 127.99,92.95 127.92,93.02
  BOTTOM w0.127: 127.92,93.02 v2(127.39,93.55)
CFG3: length 81.1
  TOP w0.127: R270.2 82.89,73.61 v2(81.6,72.32) ; CN8.39 70.56,67.95 71.06,68.45 v2(71.12,68.45)
  IN2 w0.14: v2(126.62,94.74) 124.54,94.74 124.19,94.39 118.3,94.39 116.88,92.96 116.88,92.53 116.06,91.71 115.53,91.71 112.03,88.21 111.27,88.21 109.37,86.31 109.37,82.35 102.39,75.37 101.22,75.37 100.04,74.19 94.91,74.19 94.05,75.05 90.53,75.05 89.94,74.46 83.32,74.46 81.6,72.74 v2(81.6,72.32) 77.2,67.91 71.66,67.91 v2(71.12,68.45)
  BOTTOM w0.076: U25.AA63 129.29,93.85 129.18,93.95 127.79,93.95 127.75,93.99
  BOTTOM w0.127: R543.1 125,94.67 v1(125.91,94.67) 126.55,94.67 v2(126.62,94.74) 127.36,93.99 127.75,93.99
CFG4: length 77.1
  TOP w0.127: v2(72.88,68.44) 72.88,68.11 73.06,67.92 CN8.44
  IN2 w0.14: v2(130.94,93.46) 130.49,93.91 130.23,93.91 128.31,95.84 124.52,95.84 123.91,95.23 122.94,95.23 v2(122.77,95.4) 122.59,95.22 117.98,95.22 116.17,93.41 115.59,93.41 115.31,93.13 115.31,92.62 111.7,89.01 110.9,89.01 108.46,86.56 108.46,82.7 101.92,76.17 100.89,76.17 99.7,74.99 95.24,74.99 94.38,75.85 90.2,75.85 89.61,75.26 82.62,75.26 76.5,69.14 74.57,69.14 74.32,68.9 73.33,68.9 v2(72.88,68.44)
  BOTTOM w0.127: U25.AA60 131.24,93.76 v2(130.94,93.46) ; R542.1 122.3,94.92 122.77,95.39 v2(122.77,95.4)
CFG5: length 76.6
  TOP w0.127: v1(73.3,63.93) 73.3,65.51 73.56,65.76 CN8.45 v2(73.56,68.44)
  IN2 w0.14: v2(73.56,68.44) 73.82,68.18 76.27,68.18 76.56,68.48 76.56,68.83 82.73,74.99 89.72,74.99 90.31,75.58 94.27,75.58 95.13,74.72 99.82,74.72 101,75.9 102.17,75.9 108.84,82.57 108.84,86.54 111.04,88.74 111.81,88.74 115.57,92.51 115.57,92.88 115.84,93.14 116.3,93.14 118.11,94.95 124,94.95 124.63,95.57 127.18,95.57 v2(128.02,94.73)
  BOTTOM w0.076: 128.33,94.43 128.46,94.3 129.42,94.3 129.71,94.59 U25.Y62
  BOTTOM w0.127: 128.33,94.43 v2(128.02,94.73)
CFG6: length 78.3
  TOP w0.127: CN8.47 74.56,69.53 73.78,70.32 v2(73.78,70.87)
  IN2 w0.14: v2(73.78,70.87) 75.19,72.29 77.01,72.29 81.85,77.13 88.84,77.13 89.43,77.72 96.36,77.72 97.82,79.18 101.88,79.18 106.54,83.83 106.54,87.39 107.34,88.19 107.34,88.39 111.06,92.12 111.26,92.12 114.37,95.23 114.37,95.74 117.42,98.78 127.79,98.78 128.09,98.47 128.99,98.47 129.27,98.19 129.27,95.97 v3(130.28,94.96)
  BOTTOM w0.127: v3(130.28,94.96) 130.59,94.66 U25.Y61
CFG7: length 73.3
  TOP w0.127: CN8.48 75.06,68.8 75.34,69.08 v2(77.55,69.08)
  IN2 w0.14: v3(127.34,94.76) 126.78,95.31 124.74,95.31 124.1,94.67 118.21,94.67 116.61,93.07 116.61,92.64 115.95,91.98 115.42,91.98 111.92,88.47 111.15,88.47 109.1,86.42 109.1,82.46 102.28,75.64 101.11,75.64 99.93,74.45 95.02,74.45 94.16,75.32 90.42,75.32 89.83,74.73 82.84,74.73 77.55,69.44 v2(77.55,69.08)
  BOTTOM w0.076: 127.92,94.17 127.96,94.13 129.58,94.13 129.75,94.3 130.13,94.3 130.23,94.19 130.88,94.19 U25.Y60
  BOTTOM w0.127: 127.92,94.17 v3(127.34,94.76)
CFG8: length 78.2
  TOP w0.127: CN8.26 68.56,71.6 69.61,70.55 70.98,70.55 v2(71.64,69.88)
  IN2 w0.14: v2(71.64,69.88) 72.1,69.43 74.1,69.43 74.35,69.67 76.28,69.67 82.4,75.79 89.39,75.79 89.98,76.38 98.19,76.38 98.93,75.64 99.55,75.64 100.61,76.7 101.57,76.7 107.92,83.06 107.92,86.79 110.67,89.54 111.48,89.54 114.77,92.84 114.77,93.35 115.37,93.94 115.94,93.94 118.43,96.43 126.53,96.43 126.65,96.55 v3(126.65,96.56)
  BOTTOM w0.14: U25.V62 129.51,95.76 127.45,95.76 v3(126.65,96.56)
CFG9: length 80.5
  TOP w0.127: CN8.25 69.06,71.6 69.57,71.09 v2(70.43,71.09)
  IN2 w0.14: v3(130.29,96.46) 129.54,97.21 129.54,98.46 129.26,98.74 128.35,98.74 128.03,99.06 117.32,99.06 114.11,95.85 114.11,95.34 111.15,92.38 110.82,92.38 107.02,88.58 107.02,88.25 106.27,87.5 106.27,83.96 101.76,79.45 97.71,79.45 96.26,78 82.34,78 79.58,75.24 78.3,75.24 76.02,72.95 70.99,72.95 70.43,72.39 70.43,71.1 v2(70.43,71.09)
  BOTTOM w0.127: U25.V61 130.51,95.37 130.27,95.61 130.27,96.44 v3(130.29,96.46)
CFG10: length 85.6
  TOP w0.127: v1(72.03,75.74) 72.16,75.62 v2(72.16,74.45) 70.66,74.45 70.06,73.85 CN8.23
  IN2 w0.14: v2(72.16,74.45) 72.16,74.71 73.06,75.62 75.03,75.62 76.77,77.36 77.78,77.36 80.05,79.62 96,79.62 98.76,82.38 101.3,82.38 104.06,85.14 104.06,87.18 105.43,88.55 105.43,89 110.2,93.77 110.65,93.77 112.77,95.89 112.77,99.65 113.43,100.3 116.68,100.3 116.82,100.44 118.5,100.44 118.51,100.46 128.67,100.46 128.95,100.18 131.42,100.18 132.37,99.22 132.37,96.41 v2(130.92,94.96)
  BOTTOM w0.127: v2(130.92,94.96) 131.24,95.28 U25.V60
CFG11: length 82.7
  TOP w0.127: v1(73.3,75.74) 72.75,75.19 v2(72.75,74.67) 72.75,74.36 72.39,73.99 70.66,73.99 70.56,73.89 CN8.22
  IN2 w0.14: v2(131.57,96.47) 132.03,96.93 132.03,99 131.13,99.91 128.84,99.91 128.57,100.18 116.93,100.18 116.79,100.04 113.54,100.04 113.04,99.54 113.04,95.78 110.71,93.45 110.26,93.45 105.71,88.9 105.71,88.45 104.33,87.07 104.33,85.03 100.67,81.38 98.13,81.38 95.87,79.11 80.04,79.11 78.02,77.09 76.88,77.09 75.14,75.35 73.18,75.35 72.75,74.93 v2(72.75,74.67)
  BOTTOM w0.127: v2(131.57,96.47) 131.57,96.38 U25.U60
CFG12: length 73.9
  TOP w0.127: CN8.17 73.06,69.91 v2(73.09,69.88)
  IN2 w0.14: v2(127.4,96.64) 127.39,96.64 126.99,97.03 124.1,97.03 123.75,97.38 123.04,97.38 122.35,96.7 118.26,96.7 115.77,94.21 115.26,94.21 114.51,93.46 114.51,92.95 111.37,89.81 110.46,89.81 107.66,87 107.66,83.17 101.88,77.39 100.48,77.39 v2(99.21,76.12) 98.68,76.65 89.87,76.65 89.28,76.06 82.29,76.06 76.17,69.94 74.24,69.94 74.15,69.85 73.12,69.85 v2(73.09,69.88)
  BOTTOM w0.127: U25.T63 129.07,97.05 127.82,97.05 v2(127.4,96.64)
CFG13: length 72.3
  TOP w0.127: v2(74.56,70.92) 74.16,71.32 73.79,71.32 73.56,71.55 CN8.16
  IN2 w0.14: v2(74.56,70.92) 75.65,72.02 77.12,72.02 81.96,76.86 88.95,76.86 89.54,77.45 96.47,77.45 97.12,78.1 98.51,78.1 98.52,78.09 99.65,78.09 100.48,78.91 102,78.91 106.81,83.72 106.81,87.28 110.13,90.61 111.04,90.61 113.71,93.28 113.71,93.79 114.92,95.01 115.17,95.01 118.67,98.5 127.07,98.5 127.08,98.48 127.1,98.48 127.23,98.34 127.23,98.33 v3(127.54,98.03)
  BOTTOM w0.127: v3(127.54,98.03) 127.54,97.96 128.22,97.28 128.47,97.28 128.47,97.29 129.18,97.29 129.31,97.16 129.49,97.16 129.81,96.84 U25.T62
CFG14: length 72.4
  TOP w0.127: v2(74.42,74.17) 74.56,74.03 CN8.14
  IN2 w0.14: v2(74.42,74.17) 76.86,74.17 78.19,75.5 79.47,75.5 82.24,78.28 96.16,78.28 97.6,79.71 101.65,79.71 106.01,84.07 106.01,87.61 106.73,88.34 106.73,88.67 110.71,92.65 111.04,92.65 113.84,95.45 113.84,95.96 117.22,99.34 128.27,99.34 128.61,99.01 129.47,99.01 129.83,98.64 129.83,98.41 v3(130.28,97.96)
  BOTTOM w0.127: U25.T61 130.27,97.19 130.27,97.94 v3(130.28,97.96)
CFG15: length 76.6
  TOP w0.127: CN8.13 75.06,74.16 74.59,74.63 v2(73.97,74.63) 73.97,75.14 v1(74.57,75.74)
  IN2 w0.14: v2(73.97,74.63) 74.85,74.63 75.05,74.44 76.75,74.44 78.26,75.94 78.26,76.57 80.24,78.56 96.07,78.56 97.49,79.98 101.54,79.98 105.74,84.18 105.74,87.72 106.27,88.26 106.27,88.63 110.56,92.92 110.93,92.92 113.57,95.56 113.57,96.07 117.13,99.62 128.37,99.62 128.72,99.27 129.81,99.27 130.93,98.16 v2(130.93,97.96)
  BOTTOM w0.127: v2(130.93,97.96) 130.92,97.95 130.92,97.19 U25.T60
CFG16: length 81.9
  TOP w0.127: CN8.28 67.56,71.17 68.17,70.57 69.1,70.57 69.8,69.88 v2(70.09,69.88)
  IN2 w0.14: v2(128.04,93.55) 127.59,94.01 125.19,94.01 125.02,93.83 118.57,93.83 117.42,92.68 117.42,92.32 116.28,91.18 115.76,91.18 112.25,87.67 111.5,87.67 110.04,86.22 110.04,82.13 102.75,74.84 101.44,74.84 100.26,73.65 95.27,73.65 94.21,72.59 92.2,72.59 90.87,73.93 83.8,73.93 82.32,72.44 82.32,71.94 77.77,67.38 71.17,67.38 70.4,68.16 70.4,69.49 70.09,69.79 v2(70.09,69.88)
  BOTTOM w0.076: U25.AA62 129.48,93.38 129.16,93.38 128.9,93.12 128.48,93.12 v2(128.04,93.55)
CFG17: length 83.1
  TOP w0.127: CN8.29 67.06,71.31 68.06,70.31 69,70.31 69.88,69.43 70.35,69.43 v2(70.72,69.8)
  IN2 w0.14: v3(128.73,93.53) 128.16,94.1 127.87,94.1 127.66,94.31 125.02,94.31 124.81,94.11 118.45,94.11 117.14,92.8 117.14,92.42 116.17,91.45 115.65,91.45 112.14,87.94 111.38,87.94 109.78,86.33 109.78,82.24 102.64,75.1 101.33,75.1 100.15,73.92 95.08,73.92 94.49,73.33 93.32,73.33 92.45,74.19 83.56,74.19 82.06,72.68 82.06,72.13 77.57,67.65 71.28,67.65 70.67,68.27 70.67,68.62 70.72,68.67 v2(70.72,69.8)
  BOTTOM w0.076: U25.AA61 130.31,93.88 130.06,94.13 129.81,94.13 129.64,93.96 129.64,93.78 129.41,93.55 128.74,93.55 v3(128.73,93.53)
CFG18: length 74.6
  TOP w0.127: v2(72.45,69.88) 72.45,70.58 72.06,70.97 CN8.19
  IN2 w0.14: v2(128.08,96.64) 127.42,97.3 124.21,97.3 123.85,97.66 122.59,97.66 121.89,96.96 118.04,96.96 115.56,94.48 115.14,94.48 114.24,93.57 114.24,93.06 111.26,90.08 110.35,90.08 107.34,87.06 107.34,83.24 102.48,78.38 100.7,78.38 99.59,77.27 97.94,77.27 97.59,76.92 89.76,76.92 89.17,76.33 82.18,76.33 76.06,70.21 74.13,70.21 74.04,70.12 73.49,70.12 73.28,70.33 72.91,70.33 v2(72.45,69.88)
  BOTTOM w0.14: v2(128.08,96.64) 128.63,96.09 U25.U63
CFG19: length 75.2
  TOP w0.127: v2(71.99,70.42) 71.56,70.85 CN8.20
  IN2 w0.14: v2(71.99,70.42) 72.17,70.6 73.39,70.6 73.6,70.39 73.93,70.39 74.01,70.47 75.95,70.47 82.07,76.59 89.06,76.59 89.65,77.18 97.48,77.18 97.85,77.56 99.5,77.56 100.59,78.65 102.11,78.65 107.07,83.61 107.07,87.17 110.24,90.34 111.15,90.34 113.97,93.17 113.97,93.68 115.03,94.74 115.41,94.74 118.77,98.1 124.4,98.1 124.93,97.57 127.86,97.57 v3(128.81,96.62)
  BOTTOM w0.14: v3(128.81,96.62) 128.93,96.5 129.33,96.5 129.74,96.09 U25.U62
CFG_RCOMP: length 4.7
  BOTTOM w0.381: U25.V63 127.1,95.34 126.5,95.94 v1(126.01,95.94) R537.1
CK_XDP_N: length 108.5
  TOP w0.127: RP1.3 147.15,113.83 147.34,114.02 147.34,114.58 148.74,115.98 148.74,116.56 147.8,117.5 147.31,117.5 146.99,117.83 146.62,117.83 v1(146.24,117.45) 146.24,118.17 145.41,119 140.87,119 139.95,118.08 133.5,118.08 132.83,117.41 130.01,117.41 128.98,116.38 118.98,116.38 118.35,115.75 109.7,115.75 109.19,116.26 104.02,116.26 99.85,112.09 99.85,109.71 80.67,90.53 80.67,80.34 78.05,77.72 76.84,77.72 75.53,76.41 75.53,74.77 76.56,73.74 CN8.10
