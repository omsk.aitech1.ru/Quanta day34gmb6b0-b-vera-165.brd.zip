# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ53: length 68.3
  IN2 w0.089: v2(157.04,75.82) 157.53,75.82 158.41,74.94 163.19,70.17 163.19,69.77
  IN2 w0.14: 163.19,69.77 163.19,69.11 166.71,65.58 166.71,61.93 167.23,61.41 167.23,51.39 167.07,51.22 167.07,49.07 166.68,48.69 166.68,38.51 166.1,37.92 166.1,35.77 166.39,35.48 166.39,35.1 166.11,34.82 166.11,34.49 166.39,34.21 166.39,33.83 166.11,33.55 166.11,33.1 166.39,32.82 166.39,28.88 166.09,28.58 166.09,28.3 166.37,28.02 166.86,28.02 167.25,27.63 v4(167.25,27.5)
  BOTTOM w0.076: 154.51,78.43 154.51,79.86 155.29,80.64 155.29,81.79 155.5,82 155.5,82.27 155.17,82.61 155.17,82.99 155.24,83.15 155.24,83.28 155.17,83.43 155.17,83.64 155.19,83.69 155.23,83.78 155.24,83.79 155.24,83.98 155.22,84 155.22,84.38 155.24,84.39 155.24,84.63 155.04,84.84 U25.AU23
  BOTTOM w0.127: v2(157.04,75.82) 156.23,76.63 155.31,76.63 154.58,77.36 154.58,78.36 154.51,78.43 ; JDIM2.176 v4(167.25,27.5)
M_A_DQ54: length 66.5
  IN2 w0.089: 163.53,69.77 163.53,70.07 157.32,76.28 156.96,76.28 156.19,77.06 v2(155.73,77.06)
  IN2 w0.14: 163.53,69.77 163.53,69.25 167.05,65.72 167.05,63.21 167.18,63.09 167.42,63.09 167.54,62.97 167.54,62.79 167.42,62.67 167.18,62.67 167.05,62.55 167.05,62.37 167.18,62.25 167.42,62.25 167.58,62.09 167.58,51.25 167.41,51.08 167.41,48.93 167.03,48.55 167.03,35.69 166.73,35.39 166.73,29.63 v4(167.26,29.1)
  BOTTOM w0.076: 154.84,78.56 154.84,78.6 154.72,78.73 154.72,79.83 155.46,80.57 155.46,81.72 155.67,81.93 155.67,82.34 155.33,82.68 155.33,82.95 155.38,83.06 155.4,83.11 155.4,83.31 155.38,83.37 155.34,83.46 155.33,83.47 155.33,83.6 155.36,83.65 155.38,83.71 155.52,83.84 U25.AV21
  BOTTOM w0.127: JDIM2.174 166.65,28.49 v4(167.26,29.1) ; v2(155.73,77.06) 155.2,77.06 154.84,77.42 154.84,78.56
M_A_DQ55: length 67.8
  IN2 w0.089: 162.84,69.77 162.84,70.04 158.02,74.86 v2(157.92,74.86)
  IN2 w0.14: v4(163.58,27.58) 164.72,28.71 164.72,28.89 164.42,29.18 164.42,29.35 164.54,29.48 164.72,29.48 165.39,28.81 165.82,28.81 166.05,29.04 166.05,32.66 165.76,32.94 165.76,38.06 166.34,38.65 166.34,48.62 166.13,48.83 166.13,51.1 166.72,51.69 166.72,61.44 166.16,62 166.16,62.56 166.37,62.76 166.37,63.35 166.16,63.55 166.16,63.96 166.37,64.16 166.37,64.74 166.16,64.95 166.16,65.64 162.84,68.96 162.84,69.77
  BOTTOM w0.076: U25.AU21 155.81,84.54 155.81,84.13 155.75,83.99 155.75,83.82 155.92,83.66 155.92,83.24 156.08,83.08 156.08,82.63 156.16,82.55 156.16,81.72 155.95,81.52 155.95,80.13 155.85,80.03
  BOTTOM w0.127: v2(157.92,74.86) 157.93,74.86 157.93,75.58 155.85,77.65 155.85,80.03 ; v4(163.58,27.58) 163.65,27.51 JDIM2.164
M_A_DQ56: length 65.6
  IN2 w0.089: 158.46,76.86 158.46,76.86 158.19,76.86 157.88,77.17 157.46,77.17 157.09,77.55 157.09,78.08 157.01,78.16 156.82,78.16 156.74,78.23 156.74,78.42 156.92,78.6 156.92,78.69 156.84,78.76 156.31,78.76 156.23,78.84 156.23,78.95 156.31,79.03 156.84,79.03 156.92,79.11 156.92,79.22 156.84,79.3 156.29,79.3 156.21,79.38 156.21,79.49 156.29,79.56 157.01,79.56 157.09,79.64 157.09,79.82 157.25,79.98 157.25,80.37 157.15,80.47 156.97,80.47 v2(156.6,80.1)
  IN2 w0.14: v4(169.35,32.82) 169.47,32.94 169.47,47.09 169.89,47.51 170.33,47.51 170.45,47.63 170.45,47.81 170.33,47.93 170.08,47.93 169.86,48.15 169.86,51.78 170.05,51.97 170.05,53.68 169.93,53.81 169.59,53.81 169.47,53.93 169.47,54.1 169.59,54.23 169.93,54.23 170.05,54.35 170.05,54.52 169.93,54.65 169.59,54.65 169.47,54.77 169.47,54.94 169.59,55.07 169.92,55.07 170.05,55.19 170.05,55.37 169.92,55.5 169.62,55.5 169.47,55.65 169.47,66.42 161.05,74.84 161.05,75.65 160.32,76.38 159.5,76.38 159.03,76.86 158.46,76.86
  BOTTOM w0.076: v2(156.6,80.1) 157,80.49 157,81.65 156.68,81.98 156.68,82.86 U25.AY19
  BOTTOM w0.127: JDIM2.183 v4(169.35,32.82)
M_A_DQ57: length 67
  IN2 w0.089: 159.46,75.12 159.24,75.12 157.54,76.82 157.27,76.82 156.61,77.47 156.57,77.47 155.87,78.18 155.87,78.56 155.93,78.61 155.93,79.78 156.12,79.97 156.12,80.88 v2(156.6,81.37)
  IN2 w0.14: v2(168.88,30.07) 168.52,29.7 168.52,29.2 168.4,29.09 168.22,29.09 168.11,29.2 168.11,32.7 168.78,33.37 168.78,48.16 169.17,48.55 169.17,51.38 168.78,51.77 168.78,66.09 159.75,75.12 159.46,75.12
  BOTTOM w0.076: v2(156.6,81.37) 156.51,81.46 156.51,82.66 156.41,82.76 156.41,83.26 156.69,83.54 U25.AW19
  BOTTOM w0.127: JDIM2.180 168.45,29.64 v2(168.88,30.07)
M_A_DQ58: length 65.7
  IN2 w0.14: v2(172.15,32.17) 172.14,32.17 171.94,32.38 171.94,32.66 172.14,32.87 172.39,32.87 172.52,32.99 172.53,32.99 172.53,33.26 172.4,33.38 172.06,33.38 171.94,33.5 171.94,33.67 172.06,33.8 172.4,33.8 172.53,33.92 172.53,34.09 172.4,34.22 172.06,34.22 171.94,34.34 171.94,34.51 172.06,34.64 172.4,34.64 172.53,34.76 172.53,34.93 172.4,35.05 172.06,35.05 171.94,35.18 171.94,35.35 172.06,35.47 172.4,35.47 172.53,35.6 172.53,38.66 172.4,38.79 172.06,38.79 171.94,38.91 171.94,39.08 172.06,39.21 172.4,39.21 172.53,39.33 172.53,39.5 172.4,39.63 172.06,39.63 171.94,39.75 171.94,39.92 172.06,40.04 172.4,40.04 172.53,40.17 172.53,51.73 172.05,52.21 172.05,56.38 171.49,56.93 171.49,67.28 170.74,68.02 159.03,79.74 158.45,79.74 v3(157.75,80.44)
  BOTTOM w0.076: 158.14,80.88 158.14,81.16 158.31,81.32 158.31,82.48 158.05,82.73 U25.AY17
  BOTTOM w0.127: v2(172.15,32.17) 172.74,32.17 173,32.44 173,32.72 172.82,32.89 172.49,32.89 172.35,33.03 JDIM2.193 ; v3(157.75,80.44) 157.75,80.49 158.14,80.88
M_A_DQ59: length 66.6
  IN2 w0.089: 158.17,77.35 157.59,77.35 157.26,77.68 157.26,79.33 v2(157.74,79.81)
  IN2 w0.14: v2(169.36,31.29) 169.94,31.29 170.2,31.55 170.2,34.98 169.82,35.36 169.82,38.54 169.94,38.66 170.16,38.66 170.28,38.79 170.28,38.96 170.16,39.08 169.94,39.08 169.82,39.2 169.82,39.38 169.94,39.5 170.16,39.5 170.28,39.62 170.28,39.8 170.16,39.92 169.94,39.92 169.82,40.04 169.82,40.22 169.94,40.34 170.16,40.34 170.28,40.46 170.28,40.64 170.16,40.76 169.94,40.76 169.82,40.88 169.82,46.91 169.95,47.04 170.39,47.04 170.88,47.52 170.88,51.04 170.39,51.52 170.39,55.69 169.81,56.27 169.81,66.56 163.02,73.36 163.02,74.11 160.31,76.81 159.56,76.81 159.02,77.35 158.17,77.35
  BOTTOM w0.076: U25.AW17 158.27,83.32 158.27,83.11 158.35,82.95 158.35,82.74 158.49,82.6 158.49,81.25 158.35,81.11 158.35,80.45 158.34,80.44
  BOTTOM w0.127: v2(157.74,79.81) 157.74,79.84 158.34,80.44 ; v2(169.36,31.29) 168.75,31.89 JDIM2.181
M_A_DQ60: length 67.5
  IN2 w0.089: v2(156.27,78.34) 156.27,78.11 157.39,76.99 157.72,76.99 158.03,76.69
  IN2 w0.14: v2(169,28.64) 169,28.33 169.14,28.19 169.33,28.19 169.47,28.33 169.47,30.53 168.49,31.51 168.49,32.6 169.12,33.23 169.12,48.02 169.52,48.41 169.52,51.52 169.13,51.91 169.13,66.23 160.45,74.91 160.45,75.08 160.62,75.25 160.62,75.43 160.49,75.55 160.32,75.55 160.15,75.38 159.98,75.38 159.82,75.54 159.82,75.74 158.98,76.58 158.14,76.58 158.03,76.69
  BOTTOM w0.076: U25.AV19 156.81,84.06 156.25,83.49 156.25,82.7 156.33,82.61 156.33,81.65 156.12,81.45 156.12,78.49 v2(156.27,78.34)
  BOTTOM w0.127: JDIM2.182 169.05,28.59 v2(169,28.64)
M_A_DQ61: length 67.8
  IN2 w0.14: v2(172.52,28.45) 173.18,29.11 173.18,30.1 173.01,30.26 173.01,32.28 173.21,32.49 173.21,34.36 173.34,34.48 173.61,34.48 173.76,34.63 173.76,34.75 173.61,34.9 173.33,34.9 173.21,35.01 173.21,52.01 172.82,52.4 172.82,56.62 172.59,56.85 172.59,58.05 172.29,58.36 172.29,58.72 172.54,58.98 172.54,59.41 172.17,59.78 172.17,67.56 158.02,81.71 v3(157.74,81.71)
  BOTTOM w0.076: U25.AU19 157.47,84.84 157.67,84.63 157.67,83.79 157.66,83.78 157.6,83.64 157.6,83.43 157.67,83.28 157.67,83.15 157.6,82.99 157.6,82.68 157.82,82.45 157.82,81.8 v3(157.74,81.71)
  BOTTOM w0.127: JDIM2.194 172.65,28.32 v2(172.52,28.45)
M_A_DQ62: length 66.9
  IN2 w0.14: v2(172.52,29.91) 172.67,30.06 172.67,30.25 172.52,30.4 172.26,30.4 172.13,30.53 172.13,30.71 172.26,30.84 172.52,30.84 172.67,30.99 172.67,32.44 172.87,32.64 172.87,51.87 172.39,52.35 172.39,56.56 171.83,57.12 171.83,57.3 171.98,57.46 172.09,57.46 172.24,57.6 172.24,57.81 172.09,57.96 171.98,57.96 171.83,58.12 171.83,67.42 158.98,80.27 158.55,80.27 158.39,80.42 158.39,80.82 158.14,81.08 v2(157.75,81.08)
  BOTTOM w0.076: v2(157.75,81.08) 158.13,81.46 158.13,82.38 157.76,82.74 157.76,82.95 157.81,83.06 157.84,83.11 157.84,83.31 157.81,83.37 157.81,83.37 157.77,83.46 157.76,83.47 157.76,83.6 157.81,83.71 158.05,83.95 U25.AV17
  BOTTOM w0.127: JDIM2.192 172.05,29.44 v2(172.52,29.91)
M_A_DQ63: length 67.6
  IN2 w0.14: v2(171.7,30.88) 171.59,30.99 171.59,35.99 171.75,36.14 172.03,36.14 172.16,36.27 172.16,36.45 172.03,36.58 171.72,36.58 171.59,36.7 171.59,36.88 171.72,37.01 172.03,37.01 172.16,37.13 172.16,37.31 172.03,37.44 171.75,37.44 171.59,37.59 171.59,43.15 171.75,43.31 172.03,43.31 172.16,43.43 172.16,43.61 172.03,43.74 171.75,43.74 171.59,43.89 171.59,44.51 171.85,44.77 171.85,45.01 171.59,45.27 171.59,46.39 172.18,46.98 172.18,51.58 171.7,52.07 171.7,56.23 171.14,56.79 171.14,67.14 164.11,74.17 164.11,74.24 159.31,79.05 158.95,79.05 158.79,78.88 158.63,78.88 v2(158.36,79.16)
  BOTTOM w0.076: 158.36,79.55 158.36,79.76 v2(158.42,79.82) 158.55,79.95 158.55,80.98 158.66,81.09 158.66,82.67 158.51,82.83 158.51,82.99 158.49,83.04 158.44,83.15 158.44,83.7 158.35,83.79 158.35,84.54 U25.AU17
  BOTTOM w0.127: v2(158.36,79.16) 158.36,79.55 ; v2(171.7,30.88) 170.97,31.62 170.97,31.91 171.75,32.69 JDIM2.191
M_A_DQSN0: length 79.6
  IN2 w0.14: v2(123.26,89.71) 123.45,89.51 123.45,89.34 123.35,89.24 120.09,89.24 115.05,84.19 115.05,61.66 114.19,60.8 114.19,49.11 113.87,48.78 113.87,38.32 114.11,38.07 114.11,35.57 114.69,34.99 114.69,30.76 114.06,30.13 114.06,29.62 114.87,28.81 114.87,28.54 v4(114.7,28.37)
  BOTTOM w0.076: 126.39,89.84 126.41,89.84 126.44,89.81 128.67,89.81 128.78,89.93 129.31,89.93 129.51,90.02 129.72,90.02 129.9,89.93 130.33,89.93 130.69,89.56 U25.AJ61
  BOTTOM w0.127: v2(123.26,89.71) 123.54,89.99 123.54,90.22 123.82,90.49 124.99,90.49 125.64,89.84 126.39,89.84 ; v4(114.7,28.37) 115.24,27.84 115.24,27.37 115.05,27.18 JDIM2.10
M_A_DQSN1: length 72.1
  IN2 w0.14: v4(120.58,30.27) 120.58,30.92 120.7,31.04 121.08,31.04 121.43,31.39 121.43,34.14 120.29,35.28 120.29,37.93 118.96,39.26 118.96,43.67 118.55,44.07 118.55,46.17 119.53,47.14 119.53,50.64 119.85,50.96 119.85,66.72 120.02,66.9 121.01,66.9 121.32,67.21 121.32,67.9 121.01,68.21 120.78,68.21 120.63,68.36 120.63,68.83 120.78,68.98 121.01,68.98 121.32,69.29 121.32,75 126.44,80.13 126.44,83.78 125.71,84.5 125.71,84.92 127.09,86.3 127.09,86.51 127.37,86.8 v2(127.37,86.87)
  BOTTOM w0.076: v2(127.37,86.87) 127.62,87.12 128.76,87.12 128.99,87.35 129.38,87.35 129.55,87.42 129.68,87.42 129.83,87.35 130.26,87.35 130.31,87.3 130.31,87.18 U25.AN62
  BOTTOM w0.127: v4(120.58,30.27) 120.6,30.28 120.6,30.6 120.37,30.83 120.02,30.83 119.72,31.13 119.72,32.56 120.15,32.98 JDIM2.27
M_A_DQSN2: length 64.2
  IN2 w0.14: v4(126.5,30.7) 126.34,30.86 125.96,30.86 125.63,31.19 125.63,33.67 125.9,33.94 126.1,33.94 126.24,34.08 126.24,34.58 126.1,34.72 125.9,34.72 125.63,34.99 125.63,38 123.87,39.75 123.87,46.84 124.01,46.97 124.01,52.2 125.29,53.48 125.29,59.93 125.49,60.13 125.49,72.39 130.21,77.11 130.21,77.71 131.3,78.81 131.3,80.53 131.62,80.85 131.9,80.85 v2(132.14,81.09)
  BOTTOM w0.076: U25.AV57 133.15,84.28 133.1,84.23 132.87,84.23 132.77,84.13 132.69,83.96 132.69,83.76 132.77,83.6 132.77,83.47 132.69,83.31 132.69,83.11 132.77,82.95 132.77,82.76 132.47,82.47 132.47,81.42 v2(132.14,81.09)
  BOTTOM w0.127: v4(126.5,30.7) 126.5,31.05 126.34,31.22 126.08,31.22 125.74,31.57 125.74,32.93 125.55,33.12 JDIM2.45
M_A_DQSN3: length 65.6
  IN2 w0.14: v4(131.19,29.23) 131.19,28.83 131.1,28.74 130.93,28.74 130.67,28.99 130.67,30.15 131.04,30.52 131.04,32.79 130.57,33.26 130.57,38.45 128.55,40.46 128.55,46.51 129.31,47.27 129.31,60.73 130.27,61.69 130.27,68.54 131.84,70.11 131.84,73.13 134.49,75.79 134.49,77.34 134.82,77.67 134.82,80.59 135.09,80.86 135.26,80.86 v2(135.43,80.7)
  BOTTOM w0.076: U25.AV53 135.58,84.3 135.2,83.92 135.2,83.47 135.17,83.41 135.14,83.34 135.13,83.31 135.13,83.11 135.15,83.06 135.16,83.03 135.2,82.95 135.2,82.5 134.82,82.13 134.82,81.1 134.99,80.94 135.19,80.94 v2(135.43,80.7)
  BOTTOM w0.127: v4(131.19,29.23) 131.19,28.84 130.92,28.57 130.6,28.57 130.47,28.43 130.36,28.32 130.36,28.04 130.36,27.5 130.65,27.21 JDIM2.62
M_A_DQSN4: length 64.5
  IN2 w0.076: 154.51,71.02 154.51,71.04 154.46,71.09 154.46,71.38 150.7,75.14 150.7,77.37 150.29,77.78 150.29,78.41 150.37,78.49 150.37,80.27 149.99,80.65 149.99,80.97 149.59,81.36 v2(149.59,81.44)
  IN2 w0.14: v4(155.51,31.36) 155.51,30.67 155.36,30.51 155.21,30.51 154.99,30.73 154.99,32.21 155.55,32.77 155.55,38.05 155.78,38.28 155.78,42.94 156.06,43.21 156.06,46.17 156.31,46.42 156.31,52.09 156.13,52.26 156.13,64.4 154.51,66.03 154.51,71.02
  BOTTOM w0.076: U25.AW30 149.87,83.92 149.87,84.03 149.79,84.11 149.65,84.11 149.57,84.03 149.52,83.93 149.52,83.8 149.6,83.64 149.6,83.43 149.57,83.38 149.53,83.3 149.52,83.28 149.52,83.15 149.55,83.09 149.6,82.99 149.6,82.7 149.2,82.3 149.2,81.29 149.28,81.2 149.35,81.2 v2(149.59,81.44)
  BOTTOM w0.127: v4(155.51,31.36) 155.51,30.98 155.65,30.84 155.86,30.84 156.01,30.98 156.01,32.32 155.78,32.54 155.35,32.54 155.14,32.75 155.14,32.99 154.95,33.18 JDIM2.135
M_A_DQSN5: length 64.3
  IN2 w0.089: 156.3,72.68 156.28,72.7 156.28,72.76 156.07,72.97 155.96,72.97 153.04,75.89 153.04,76.25 152.64,76.65 152.64,79.02 152.72,79.1 152.72,80.76 152.6,80.87 152.32,80.87 v2(152.21,80.76)
  IN2 w0.14: v4(159.71,28.25) 160.22,28.75 160.22,33.24 160.51,33.54 160.51,38.69 160.61,38.79 160.61,47.24 161.16,47.78 161.16,64.52 158.51,67.17 158.51,70.47 156.3,72.68
  BOTTOM w0.076: U25.AV26 152.02,84.29 152.02,84.11 151.86,83.95 151.86,83.47 151.79,83.31 151.79,83.11 151.86,82.95 151.86,82.65 151.62,82.41 151.49,82.28 151.49,81.37 151.88,80.99 152.02,80.99 152.21,80.8 v2(152.21,80.76)
  BOTTOM w0.127: JDIM2.152 160.05,27.18 160.24,27.37 160.24,27.72 v4(159.71,28.25)
M_A_DQSN6: length 66.3
  IN2 w0.089: 159.09,73.04 159.08,73.05 159.08,73.12 158.58,73.61 158.35,73.61 154.56,77.4 154.56,79.96 154.25,80.27 154.25,81.04 154.41,81.21 154.67,81.21 v2(154.9,81.44)
  IN2 w0.14: 159.09,73.04 162.06,70.07 162.06,68.64 165.38,65.32 165.38,61.67 165.94,61.11 165.94,52.02 165.26,51.35 165.26,46.2 164.93,45.87 164.93,42.8 165.11,42.62 165.11,38.53 164.93,38.35 164.93,32.51 164.48,32.07 164.48,31.03 164.74,30.77 165.13,30.77 165.3,30.6 v4(165.3,30.24)
  BOTTOM w0.076: v2(154.9,81.44) 154.64,81.7 154.64,82.61 154.73,82.7 154.73,82.99 154.7,83.04 154.66,83.15 154.66,83.28 154.66,83.3 154.7,83.38 154.73,83.43 154.73,83.64 154.66,83.8 154.66,83.93 154.7,84.03 154.79,84.11 154.87,84.11 154.95,84.04 U25.AW22
  BOTTOM w0.127: JDIM2.169 165.15,33.22 165.34,33.04 165.34,32.9 165.2,32.77 164.97,32.77 164.44,32.23 164.44,31.29 164.9,30.84 165.14,30.84 165.3,30.68 v4(165.3,30.24)
M_A_DQSN7: length 67.2
  IN2 w0.14: v2(157.76,77.75) 158,78 159.17,78 159.7,77.47 160.13,77.04 160.45,77.04 163.37,74.12 163.37,73.8 170.33,66.84 170.33,56.49 170.91,55.91 170.91,51.74 171.4,51.26 171.4,47.31 170.81,46.72 170.81,30.44 170.53,30.17 170.53,29.97 v2(170,29.44)
  BOTTOM w0.076: U25.AV18 157.38,84.33 157.07,84.02 157.07,83.91 156.99,83.83 156.99,83.47 156.94,83.35 156.92,83.31 156.92,83.11 157,82.95 157,82.76 156.84,82.61 156.84,82.04 157.16,81.72 157.16,78.24 157.36,78.04 157.62,78.04 157.76,77.9 v2(157.76,77.75)
  BOTTOM w0.127: v2(170,29.44) 170.51,28.93 170.51,27.38 170.25,27.12 JDIM2.186
M_A_DQSP0: length 79.3
  IN2 w0.14: v2(124.02,89.71) 123.72,89.41 123.72,89.23 123.46,88.97 120.2,88.97 115.31,84.08 115.31,61.55 114.46,60.69 114.46,49 114.13,48.67 114.13,38.43 114.38,38.18 114.38,35.68 114.96,35.1 114.96,30.65 114.32,30.02 114.32,29.73 115.14,28.92 115.14,28.54 115.3,28.37 v4(115.97,28.37)
  BOTTOM w0.076: U25.AJ62 130.3,89.6 130.3,89.72 130.26,89.76 129.86,89.76 129.77,89.81 129.68,89.85 129.55,89.85 129.35,89.76 128.85,89.76 128.73,89.65 126.44,89.65 126.41,89.62 126.39,89.62
  BOTTOM w0.127: v4(115.97,28.37) 115.47,27.86 115.47,27.36 115.65,27.18 JDIM2.12 ; 126.39,89.62 125.54,89.62 124.9,90.26 123.91,90.26 123.77,90.13 123.77,89.95 v2(124.02,89.71)
M_A_DQSP1: length 72.1
  IN2 w0.14: v2(126.74,86.8) 126.82,86.72 126.82,86.41 125.45,85.03 125.45,84.39 126.17,83.67 126.17,80.24 121.05,75.12 121.05,69.4 120.9,69.25 120.67,69.25 120.36,68.94 120.36,68.25 120.67,67.94 120.9,67.94 121.05,67.79 121.05,67.32 120.9,67.16 119.91,67.16 119.58,66.83 119.58,51.07 119.26,50.75 119.26,47.25 118.29,46.28 118.29,43.96 118.69,43.56 118.69,39.15 120.02,37.82 120.02,35.17 121.16,34.03 121.16,31.5 120.96,31.3 120.76,31.3 120.58,31.47 v4(120.58,31.54)
  BOTTOM w0.076: U25.AN61 130.41,87.43 130.33,87.51 129.87,87.51 129.72,87.59 129.51,87.59 129.34,87.51 128.92,87.51 128.69,87.28 127.23,87.28 126.74,86.8 v2(126.74,86.8)
  BOTTOM w0.127: JDIM2.29 120.75,33.06 120.39,32.7 120.19,32.7 119.95,32.46 119.95,31.22 120.11,31.06 120.45,31.06 120.58,31.19 v4(120.58,31.54)
M_A_DQSP2: length 63.9
  IN2 w0.14: v2(132.14,80.45) 132.01,80.58 131.73,80.58 131.57,80.42 131.57,78.69 130.48,77.6 130.48,77 125.75,72.27 125.75,60.02 125.55,59.82 125.55,53.37 124.28,52.09 124.28,46.86 124.14,46.72 124.14,39.86 125.89,38.11 125.89,35.1 126.01,34.98 126.21,34.98 126.5,34.69 126.5,33.97 126.21,33.67 126.01,33.67 125.89,33.56 125.89,31.3 126.07,31.13 126.36,31.13 126.5,31.27 v4(126.5,31.97)
  BOTTOM w0.076: v2(132.14,80.45) 132.64,80.95 132.64,82.4 132.93,82.7 132.93,82.99 132.86,83.15 132.86,83.28 132.93,83.43 132.93,83.64 132.86,83.8 132.86,83.93 132.91,84.03 132.94,84.06 133.03,84.06 133.15,83.94 U25.AW57
  BOTTOM w0.127: JDIM2.47 126.15,33.12 125.96,32.93 125.96,31.66 126.18,31.45 126.36,31.45 126.5,31.58 v4(126.5,31.97)
M_A_DQSP3: length 65.2
  IN2 w0.14: v4(131.19,27.96) 131.19,28.29 131.01,28.47 130.82,28.47 130.41,28.88 130.41,30.26 130.77,30.63 130.77,32.68 130.3,33.15 130.3,38.34 128.29,40.35 128.29,46.62 129.05,47.38 129.05,60.84 130,61.8 130,68.65 131.57,70.22 131.57,73.24 134.22,75.9 134.22,77.45 134.55,77.78 134.55,80.7 134.98,81.13 135.22,81.13 v2(135.42,81.33)
  BOTTOM w0.076: U25.AW53 135.54,83.91 135.42,83.91 135.36,83.85 135.36,83.43 135.32,83.34 135.3,83.29 135.29,83.28 135.29,83.17 arc(135.29,83.15) 135.3,83.12 135.32,83.09 135.36,83 arc(135.36,82.99) 135.36,82.97 135.36,82.44 134.99,82.06 134.99,81.17 135.06,81.1 135.19,81.1 v2(135.42,81.33)
  BOTTOM w0.127: JDIM2.64 131.25,26.96 130.59,27.62 130.59,28.14 130.59,28.23 130.7,28.34 131.02,28.34 131.19,28.16 v4(131.19,27.96)
M_A_DQSP4: length 64.4
  IN2 w0.076: v2(149.59,80.81) 150.2,80.2 150.2,78.55 150.12,78.48 150.12,77.71 150.53,77.3 150.53,75.07 154.29,71.31 154.29,71.09 154.24,71.04 154.24,71.02
  IN2 w0.14: v4(155.51,30.09) 155.35,30.25 155.1,30.25 154.72,30.62 154.72,32.32 155.28,32.88 155.28,38.16 155.51,38.39 155.51,43.05 155.79,43.33 155.79,46.28 156.04,46.53 156.04,51.98 155.87,52.15 155.87,64.29 154.24,65.92 154.24,71.02
  BOTTOM w0.076: U25.AV30 149.81,84.37 149.72,84.28 149.58,84.28 149.49,84.19 149.43,84.13 149.36,83.96 149.36,83.76 149.38,83.7 149.43,83.6 149.43,83.47 149.36,83.31 149.36,83.11 149.38,83.06 149.38,83.05 149.43,82.95 149.43,82.76 149.03,82.37 149.03,81.22 149.21,81.04 149.36,81.04 v2(149.59,80.81)
  BOTTOM w0.127: JDIM2.137 155.55,33.17 155.36,32.99 155.36,32.85 155.45,32.77 155.88,32.77 156.23,32.41 156.23,30.89 155.95,30.61 155.6,30.61 155.51,30.52 v4(155.51,30.09)
M_A_DQSP5: length 63.9
  IN2 w0.089: v2(152.21,81.42) 152.21,81.33 152.48,81.05 152.68,81.05 152.9,80.83 152.9,79.02 152.81,78.94 152.81,76.72 153.22,76.32 153.22,75.96 156.03,73.15 156.15,73.15 156.25,73.05 156.41,72.89 156.47,72.89 156.49,72.87
  IN2 w0.14: 156.49,72.87 158.78,70.58 158.78,67.28 161.43,64.63 161.43,47.67 160.88,47.13 160.88,38.68 160.78,38.58 160.78,33.43 160.48,33.13 160.48,28.75 v4(160.98,28.25)
  BOTTOM w0.076: U25.AW26 152.03,83.64 152.03,83.43 152,83.38 151.96,83.3 151.95,83.28 151.95,83.15 151.98,83.09 152.03,82.99 152.03,82.58 151.74,82.29 151.66,82.21 151.66,81.44 151.95,81.15 152.11,81.15 152.21,81.26 v2(152.21,81.42)
  BOTTOM w0.127: JDIM2.154 160.65,27.18 160.46,27.37 160.46,27.73 v4(160.98,28.25)
M_A_DQSP6: length 66.1
  IN2 w0.089: v2(154.9,80.81) 154.9,80.89 154.76,81.03 154.49,81.03 154.43,80.97 154.43,80.34 154.74,80.03 154.74,77.47 158.43,73.79 158.66,73.79 159.22,73.23 159.28,73.23
  IN2 w0.14: 159.28,73.23 162.32,70.18 162.32,68.75 165.64,65.43 165.64,61.78 166.2,61.22 166.2,51.91 165.53,51.24 165.53,46.09 165.2,45.76 165.2,42.91 165.38,42.73 165.38,38.42 165.19,38.24 165.19,32.4 164.75,31.96 164.75,31.14 164.85,31.04 165.17,31.04 165.3,31.17 v4(165.3,31.51)
  BOTTOM w0.076: U25.AV22 154.95,84.36 154.87,84.28 154.72,84.28 154.63,84.19 154.56,84.12 154.55,84.1 154.49,83.96 154.49,83.76 154.52,83.7 154.56,83.6 154.56,83.47 154.49,83.31 154.49,83.11 154.51,83.06 154.52,83.05 154.56,82.95 154.56,82.76 154.47,82.67 154.47,81.23 v2(154.9,80.81)
  BOTTOM w0.127: JDIM2.171 165.75,33.19 165.56,33 165.56,32.81 165.29,32.54 165.07,32.54 164.67,32.14 164.67,31.39 164.99,31.06 165.22,31.06 165.3,31.15 v4(165.3,31.51)
M_A_DQSP7: length 66.6
  IN2 w0.14: v2(157.76,78.51) 158,78.26 159.28,78.26 159.89,77.66 160.24,77.31 160.56,77.31 163.64,74.23 163.64,73.91 170.6,66.95 170.6,56.6 171.18,56.02 171.18,51.85 171.66,51.37 171.66,47.2 171.07,46.6 171.07,30.33 170.8,30.06 170.8,29.91 v2(171.27,29.44)
  BOTTOM w0.076: v2(157.76,78.51) 157.76,78.36 157.61,78.21 157.43,78.21 157.33,78.31 157.33,81.79 157.01,82.11 157.01,82.54 157.16,82.69 157.16,82.99 157.08,83.15 157.08,83.27 157.1,83.3 157.12,83.35 157.14,83.38 157.16,83.43 157.16,83.76 157.26,83.86 U25.AW18
  BOTTOM w0.127: v2(171.27,29.44) 170.74,28.91 170.74,27.38 170.85,27.27 JDIM2.188
M_A_ODT0: length 2.5
  TOP w0.203: v2(149.12,24.64) 149.36,24.87 R366.2
  BOTTOM w0.191: JDIM2.116 149.25,24.77 v2(149.12,24.64)
M_A_ODT1: length 4.2
  TOP w0.127: v2(150.01,24.64) 150.01,24.57 v1(151.03,23.55)
  TOP w0.191: v2(150.01,24.64) 150.5,25.14 R367.2
  BOTTOM w0.203: v2(150.01,24.64) 150.45,25.09 JDIM2.120
M_A_RAS#: length 62.6
  IN2 w0.089: 147.78,74.02 148.06,74.3 148.06,81.23 v2(147.48,81.81)
  IN2 w0.216: v4(147.9,28.07) 147.65,27.81 147.65,27.42 147.46,27.23 147.19,27.23 147,27.42 147,28.18 147.74,28.92 147.74,31.77 148.19,32.22 148.19,33.21 148.66,33.69 148.66,39.63 147.92,40.38 147.92,45.31 148.39,45.78 148.39,47.56 148.85,48.02 148.85,53.48 149.87,54.5 149.87,59.34 148.87,60.34 148.87,61.88 147.63,63.12 147.63,73.87 147.78,74.02
  BOTTOM w0.089: U25.AY34 147.89,82.23 v2(147.48,81.81)
  BOTTOM w0.191: v4(147.9,28.07) 147.45,27.61 JDIM2.110
M_A_WE#: length 62.5
  IN2 w0.089: v3(147.48,83.2) 148.24,82.44 148.24,73.84 148.36,73.72 148.36,73.39
  IN2 w0.216: 148.36,73.39 148.36,63.15 149.46,62.05 149.46,60.48 150.39,59.56 150.39,54.28 149.46,53.35 149.46,47.89 148.91,47.35 148.91,45.03 148.63,44.75 148.63,44.31 148.96,43.98 148.96,40.8 149.19,40.58 149.19,33.47 148.71,33 148.71,32 148.26,31.56 148.26,30.06 148.56,29.76 149.15,29.76 149.62,30.23 v2(149.62,30.48)
  BOTTOM w0.089: v3(147.48,83.2) 147.82,83.54 U25.AW34
  BOTTOM w0.191: v2(149.62,30.48) 149.62,31.02 148.35,32.29 JDIM2.113
M_B_A0: length 49.8
  IN1 w0.076: v2(143.37,86.32) 142.91,85.86 142.91,85.41 143.34,84.98 143.34,80 142.63,79.3 142.63,75.17 142.26,74.8 142.26,74.47
  IN1 w0.216: v4(144.2,42.8) 143.56,43.44 143.56,46.22 142.97,46.82 142.97,52.18 142.26,52.89 142.26,74.47
  BOTTOM w0.076: U25.AP40 143.7,86.65 v2(143.37,86.32)
  BOTTOM w0.191: JDIM1.98 143.85,40.52 144.02,40.69 144.29,40.69 144.7,41.1 144.7,42.3 v4(144.2,42.8)
M_B_A1: length 49.1
  IN1 w0.076: v2(143.37,85.58) 143.58,85.58 143.69,85.47 143.69,84.99 143.53,84.83 143.53,79.62 143.42,79.51 143.42,75.39 143.23,75.2
  IN1 w0.216: 143.23,75.2 142.78,74.75 142.78,53.11 143.76,52.13 143.76,48.71 144.02,48.45 144.39,48.45 144.61,48.22 144.61,47.89 144.39,47.66 143.89,47.66 143.66,47.43 143.66,47.1 143.89,46.87 144.29,46.87 144.47,46.69 144.47,46.18 144.2,45.9 v4(144.2,44.22)
  BOTTOM w0.076: U25.AR40 v2(143.37,85.58)
  BOTTOM w0.191: v4(144.2,44.22) 144.05,44.07 143.76,44.07 143.55,44.28 JDIM1.97
M_B_A2: length 53.7
  IN1 w0.076: 141.86,77.09 141.86,77.54 142.19,77.87 142.19,85 142.06,85.13 142.06,85.93 v2(142.48,86.34)
  IN1 w0.216: v4(144.2,41.33) 143.49,42.04 143.49,42.77 142.92,43.35 142.92,44.64 141.86,45.7 141.86,48.56 141.15,49.27 141.15,53.49 138.27,56.37 138.27,57.09 138.81,57.63 141.03,57.63 141.22,57.82 141.22,74.85 141.86,75.49 141.86,77.09
  BOTTOM w0.076: U25.AP42 142.78,86.65 v2(142.48,86.34)
  BOTTOM w0.191: v4(144.2,41.33) 143.81,41.33 143.25,40.76 JDIM1.96
M_B_A3: length 51.2
  IN1 w0.076: 142.26,77.09 142.26,77.7 142.42,77.86 142.42,79.42 143.17,80.17 143.17,84.7 142.45,85.41 v2(142.45,85.71)
  IN1 w0.216: 142.26,77.09 142.26,75.4 141.74,74.89 141.74,57.34 141.51,57.11 139.04,57.11 138.85,56.92 138.85,56.65 139.04,56.46 141.49,56.46 141.68,56.27 141.68,56.01 141.49,55.82 140.21,55.82 140.02,55.63 140.02,55.36 140.21,55.17 141.49,55.17 141.67,54.99 141.67,49.64 142.38,48.93 142.38,46.67 v4(142.9,46.15)
  BOTTOM w0.076: v2(142.45,85.71) 142.68,85.71 U25.AR42
  BOTTOM w0.191: JDIM1.95 142.95,46.21 142.9,46.16 v4(142.9,46.15)
M_B_A4: length 56
  IN1 w0.076: 141.63,80.86 141.63,84.7 140.71,85.63 v2(140.67,85.63)
  IN1 w0.216: 141.63,80.86 141.63,78.6 140.32,77.28 140.32,73.64 140.17,73.49 140.17,60.28 139.86,59.97 137.53,59.97 137.22,59.66 137.22,55.95 140.11,53.06 140.11,48.84 140.75,48.2 140.75,45.67 141.53,44.88 141.53,39.68 141.72,39.49 141.99,39.49 142.18,39.68 v4(142.18,41.18)
  BOTTOM w0.076: U25.AR45 v2(140.67,85.63)
  BOTTOM w0.191: v4(142.18,41.18) 142.05,41.05 JDIM1.92
M_B_A5: length 54.6
  IN1 w0.076: 141.46,77.32 141.46,77.44 141.96,77.95 141.96,84.71 141.07,85.6 141.07,86.56 141.14,86.63 141.45,86.63 141.55,86.53 v2(141.55,86.37)
  IN1 w0.216: 141.46,77.32 141.46,75.55 140.7,74.79 140.7,59.64 140.51,59.45 137.93,59.45 137.74,59.26 137.74,58.99 137.93,58.8 140.51,58.8 140.7,58.61 140.7,58.34 140.51,58.15 137.93,58.15 137.74,57.96 137.74,56.17 140.63,53.27 140.63,49.05 141.34,48.34 v4(141.34,45.83)
  BOTTOM w0.076: U25.AP45 141.27,86.65 v2(141.55,86.37)
  BOTTOM w0.191: JDIM1.91 141.75,46.24 v4(141.34,45.83)
M_B_A6: length 59.5
  IN1 w0.076: 139.93,74.47 139.93,74.6 140.01,74.69 140.01,77.44 141.2,78.62 v2(141.2,81.74)
  IN1 w0.216: 139.93,74.47 139.93,74.21 139.65,73.93 139.65,60.83 139.32,60.49 137.13,60.49 136.67,60.03 136.67,55.76 139.51,52.92 139.51,48.7 140.22,47.99 140.22,45.43 141.01,44.64 141.01,38.82 141.24,38.59 142.47,38.59 142.7,38.82 142.7,42.1 v4(142.18,42.62)
  BOTTOM w0.076: v2(141.2,81.74) 140.46,82.47 140.46,83.08 140.02,83.53 U25.AW46
  BOTTOM w0.191: JDIM1.90 141.45,41.89 v4(142.18,42.62)
M_B_A7: length 61.5
  IN1 w0.076: 138.93,74.56 138.93,74.67 139.39,75.13 139.39,78.37 140.1,79.08 140.1,80.09 v2(139.62,80.57)
  IN1 w0.216: v4(139.6,42.49) 140.32,41.77 140.32,39.32 138.42,37.41 137.73,37.41 137.23,37.9 137.23,38.61 138.56,39.94 138.56,43.22 138.66,43.32 138.66,47.34 137.95,48.05 137.95,52.27 135.11,55.12 135.11,62.69 135.77,63.35 137.71,63.35 138.09,63.73 138.09,73.72 138.93,74.56
  BOTTOM w0.076: U25.AY46 140.02,82.88 140.02,80.97 v2(139.62,80.57)
  BOTTOM w0.191: v4(139.6,42.49) 140.25,41.84 JDIM1.86
M_B_A8: length 58
  IN1 w0.076: 139.61,74.47 139.61,74.6 139.8,74.79 139.8,77.77 140.74,78.71 140.74,83.41 140.57,83.58 140.38,83.58 140.2,83.4 140.2,82.68 140.05,82.53 v2(139.63,82.53)
  IN1 w0.216: v4(140.23,43.61) 140.18,43.61 139.7,44.09 139.7,47.77 138.99,48.48 138.99,52.7 136.15,55.55 136.15,60.82 136.34,61.01 138.94,61.01 139.13,61.2 139.13,61.47 138.94,61.66 136.34,61.66 136.15,61.85 136.15,62.12 136.34,62.31 138.94,62.31 139.13,62.5 139.13,73.86 139.61,74.34 139.61,74.47
  BOTTOM w0.076: U25.AY47 139.54,82.53 v2(139.63,82.53)
  BOTTOM w0.191: JDIM1.89 141.15,46.54 140.59,45.98 140.59,45.7 139.7,44.81 139.7,44.15 v4(140.23,43.61)
M_B_A9: length 60.7
  IN1 w0.076: 138.33,74.85 138.33,78.41 139.21,79.29 139.21,84.08 139.27,84.14 139.51,84.14 139.61,84.05 v2(139.61,83.88)
  IN1 w0.216: v4(138.13,44.1) 138.13,43.52 137.96,43.34 137.7,43.34 137.53,43.52 137.53,47 136.91,47.62 136.91,48.9 136.72,49.09 136.56,49.09 136.37,49.28 136.37,49.54 136.56,49.73 136.72,49.73 136.91,49.92 136.91,50.19 136.72,50.38 136.56,50.38 136.37,50.57 136.37,50.84 136.56,51.03 136.72,51.03 136.91,51.22 136.91,51.5 136.74,51.68 136.52,51.68 136.37,51.83 136.37,52.38 133.97,54.78 133.97,65.54 134.15,65.72 134.98,65.72 135.17,65.91 135.17,66.17 134.98,66.36 134.16,66.36 133.97,66.55 133.97,66.82 134.16,67.01 136.86,67.01 137.05,67.2 137.05,67.47 136.86,67.66 135.38,67.66 135.2,67.85 135.2,68.12 135.38,68.31 136.86,68.31 137.05,68.5 137.05,68.76 136.93,68.89 136.86,68.95 136.63,68.95 136.44,69.14 136.44,69.41 136.63,69.6 136.79,69.6 137.05,69.86 137.05,73.58 138.33,74.85
  BOTTOM w0.076: v2(139.61,83.88) 139.61,84.38 U25.AU46
  BOTTOM w0.191: JDIM1.85 139.95,45.87 138.83,44.76 138.83,44.6 138.33,44.1 v4(138.13,44.1)
M_B_A10: length 64.2
  IN1 w0.076: 145.54,74.45 145.54,74.55 145.68,74.69 145.68,78.14 145.17,78.66 145.17,85.41 145.27,85.51 145.27,86.81 145.27,86.82 145.27,87.49 145.36,87.58 145.36,89.26 145.49,89.38 145.72,89.38 145.82,89.28 v2(145.82,89.08)
  IN1 w0.216: v4(146.47,50.61) 146.92,51.06 146.92,53.45 148,54.53 148,56.31 147.81,56.5 146.15,56.5 145.96,56.69 145.96,56.95 146.15,57.14 147.81,57.14 148,57.33 148,57.6 147.81,57.79 146.02,57.79 145.83,57.98 145.83,58.25 146.02,58.44 147.81,58.44 148,58.63 148,58.9 147.81,59.09 145.52,59.09 145.33,59.28 145.33,59.54 145.52,59.73 147.81,59.73 148,59.92 148,60.19 147.81,60.38 145.52,60.38 145.33,60.57 145.33,60.84 145.52,61.03 147.81,61.03 148,61.22 148,61.49 147.81,61.68 145.52,61.68 145.33,61.87 145.33,73.63 145.54,73.84 145.54,74.45
  BOTTOM w0.076: v2(145.82,89.08) 145.99,89.25 U25.AK36
  BOTTOM w0.191: v4(146.47,50.61) 146.96,50.12 146.96,49.56 146.55,49.15 JDIM1.107
M_B_A11: length 60.1
  IN1 w0.076: 139.29,74.47 139.34,74.52 139.34,74.73 139.63,75.02 139.63,78.1 140.44,78.91 140.44,82.04 140.34,82.15 140.17,82.15 140.08,82.05 140.08,81.35 139.96,81.23 v2(139.62,81.23)
  IN1 w0.216: v4(139.6,40.94) 139.73,40.81 139.73,39.46 138.2,37.93 137.94,37.93 137.75,38.12 137.75,38.4 139.08,39.73 139.08,43.01 139.18,43.11 139.18,47.56 138.47,48.27 138.47,52.48 135.63,55.33 135.63,62.47 135.98,62.83 138.27,62.83 138.61,63.17 138.61,73.79 139.29,74.47
  BOTTOM w0.076: U25.AV47 138.9,83.89 138.9,81.95 v2(139.62,81.23)
  BOTTOM w0.191: v4(139.6,40.94) 139.65,40.89 JDIM1.84
M_B_A12: length 56.7
  IN1 w0.076: v2(139.61,79.27) 139.61,79.1 139.23,78.72 139.23,75.22 138.78,74.78 138.7,74.78
  IN1 w0.216: v4(138.14,45.38) 138.14,47.12 137.43,47.83 137.43,52.05 134.58,54.9 134.58,63.58 134.87,63.87 137.38,63.87 137.57,64.06 137.57,64.33 137.38,64.52 134.78,64.52 134.59,64.71 134.59,64.97 134.78,65.16 137.38,65.16 137.57,65.35 137.57,65.62 137.38,65.81 135.88,65.81 135.69,66 135.69,66.27 135.88,66.46 137.27,66.46 137.57,66.76 137.57,73.65 138.7,74.78
  BOTTOM w0.076: U25.AU47 139.14,84.63 138.73,84.22 138.73,80.19
  BOTTOM w0.191: JDIM1.83 139.35,46.59 v4(138.14,45.38) ; 138.73,80.19 138.73,80.04 139.5,79.27 v2(139.61,79.27)
M_B_A13: length 65.3
  IN1 w0.076: 148.61,74.24 148.47,74.37 148.47,76.51 148.23,76.75 147.88,77.11 147.88,83.62 147.98,83.72 147.98,85.35 148.3,85.66 148.3,87.27 148.13,87.44 148.13,88.42 147.72,88.83 v2(147.72,88.87)
  IN1 w0.216: v4(152.05,44.75) 152.05,44.28 152.56,43.77 152.56,39.43 152.37,39.24 152.1,39.24 151.91,39.43 151.91,43.4 151.17,44.15 151.17,47.83 152,48.66 152,52.79 154.25,55.04 154.25,63.68 149.44,68.5 149.44,73.41 148.61,74.24
  BOTTOM w0.076: U25.AK33 148.1,89.25 v2(147.72,88.87)
  BOTTOM w0.191: JDIM1.119 150.15,45.61 151,44.75 v4(152.05,44.75)
M_B_A14: length 61.7
  IN1 w0.076: 137.46,74.47 138.03,75.04 138.03,78.44 139.04,79.46 139.04,84.3 139.89,85.14 139.89,86.09 140.28,86.48 140.49,86.48 140.57,86.4 v2(140.57,86.26)
  IN1 w0.216: 137.46,74.47 136.53,73.54 136.53,70.31 133.45,67.23 133.45,54.56 135.85,52.16 135.85,48.89 136.39,48.35 136.39,47.4 137.01,46.79 137.01,42.55 136.83,42.38 136.83,40.62 135.61,39.4 135.61,39.13 135.8,38.93 136.08,38.93 137.48,40.34 137.48,42.08 v4(138,42.6)
  BOTTOM w0.076: v2(140.57,86.26) 140.31,86 U25.AR46
  BOTTOM w0.191: v4(138,42.6) 138.09,42.6 138.54,42.15 138.54,40.93 138.45,40.83 JDIM1.80
M_B_A15: length 61.7
  IN1 w0.076: 136.9,74.47 137.79,75.36 137.79,78.55 138.88,79.63 138.88,84.36 139.72,85.21 139.72,86.16 140.21,86.64 140.47,86.64 140.57,86.74 v2(140.57,86.97)
  IN1 w0.216: 136.9,74.47 136.01,73.58 136.01,70.52 132.93,67.44 132.93,54.35 135.33,51.94 135.33,48.68 135.87,48.14 135.87,47.19 136.49,46.57 136.49,43.18 136.22,42.92 136.22,40.75 134.82,39.35 134.82,38.42 135.26,37.98 135.86,37.98 138,40.12 v4(138,41.17)
  BOTTOM w0.076: v2(140.57,86.97) 140.25,86.65 U25.AP46
  BOTTOM w0.191: v4(138,41.17) 137.85,41.02 JDIM1.78
M_B_BS#0: length 65.5
  IN1 w0.076: 146.37,74.55 146.18,74.75 146.18,76.78 146.35,76.96 146.35,78 145.5,78.86 145.5,84.65 146.24,85.39 146.24,85.99 146.22,86.01 146.22,86.93 146.23,86.93 146.23,87.27 146.2,87.29 146.2,88.44 146.3,88.54 146.65,88.54 146.78,88.42 v3(146.78,88.25)
  IN1 w0.216: 146.37,74.55 146.37,66.81 146.58,66.6 146.77,66.6 146.96,66.41 146.96,66.15 146.77,65.96 146.55,65.96 146.37,65.78 146.37,65.5 146.56,65.31 148.37,65.31 148.56,65.12 148.56,64.85 148.37,64.66 146.56,64.66 146.37,64.47 146.37,64.2 146.56,64.01 149.14,64.01 149.32,63.82 149.32,63.56 149.14,63.37 146.56,63.37 146.37,63.18 146.37,62.91 146.56,62.72 148.42,62.72 149.12,62.02 149.12,58.41 149.34,58.18 151.05,58.18 151.24,57.99 151.24,57.72 151.05,57.54 149.24,57.54 149.05,57.35 149.05,57.08 149.24,56.89 151.05,56.89 151.24,56.7 151.24,56.43 151.05,56.24 149.24,56.24 149.05,56.05 149.05,55.78 149.24,55.59 149.9,55.59 150.09,55.4 150.09,55.13 149.9,54.94 149.38,54.94 149.1,54.66 149.1,54.15 148.08,53.13 v2(148.08,52.2)
  BOTTOM w0.076: v3(146.78,88.25) 147.12,88.6 U25.AL35
  BOTTOM w0.191: v2(148.08,52.2) 147.39,51.51 147.39,49.38 147.15,49.13 JDIM1.109
M_B_BS#1: length 64.5
  IN1 w0.076: 145.93,74.45 145.93,78.13 145.33,78.73 145.33,85.35 145.44,85.45 145.44,86.29 145.43,86.3 145.43,86.62 145.44,86.63 145.44,87.42 v2(145.79,87.78)
  IN1 w0.216: v4(148.44,42.39) 149.01,41.82 149.01,38.19 148.78,37.96 147.37,37.96 147.14,38.19 147.14,43.79 148.08,44.72 148.08,48.36 147.45,49 147.45,53.23 148.52,54.31 148.52,61.88 148.21,62.2 146.27,62.2 145.85,62.61 145.85,73.51 145.93,73.59 145.93,74.45
  BOTTOM w0.076: U25.AM36 145.96,87.95 v2(145.79,87.78)
  BOTTOM w0.191: JDIM1.108 146.85,40.55 147.03,40.73 147.03,41.56 147.85,42.39 v4(148.44,42.39)
M_B_BS#2: length 60.1
  IN1 w0.076: 136.46,74.47 137.63,75.65 137.63,78.66 138.71,79.74 138.71,81.88 138.44,82.16 138.44,82.56 138.71,82.83 138.71,83.07 138.43,83.35 138.43,83.62 138.71,83.9 138.71,84.11 138.5,84.33 138.18,84.33 138.02,84.17 v2(138.02,83.86)
  IN1 w0.216: 136.46,74.47 135.49,73.51 135.49,70.74 132.41,67.66 132.41,53.69 132.69,53.41 133.13,53.41 133.34,53.2 133.34,52.9 133.13,52.69 132.6,52.69 132.41,52.5 132.41,52.24 132.6,52.05 133.92,52.05 134.11,51.86 134.11,51.59 133.92,51.4 133.15,51.4 132.94,51.2 132.94,51 133.19,50.75 133.92,50.75 134.13,50.54 134.13,49.14 135.35,47.92 135.35,46.35 135.54,46.16 135.77,46.16 135.96,45.97 135.96,45.7 135.77,45.52 135.54,45.52 135.35,45.33 135.35,43.89 135.51,43.72 135.82,43.72 135.96,43.87 v4(135.96,44.22)
  BOTTOM w0.076: U25.AU49 138.02,84.36 v2(138.02,83.86)
  BOTTOM w0.191: JDIM1.79 138.15,46.09 137.16,45.1 137.16,43.03 136.93,42.8 136.43,42.8 136.28,42.95 136.28,43.91 v4(135.96,44.22)
M_B_CAS#: length 64.6
  IN1 w0.076: 148.43,73.86 148.28,74.02 148.28,76.1 147.93,76.46 147.64,76.75 147.64,78.22 147.04,78.82 147.04,84.66 148.13,85.75 148.13,87.18 147.72,87.58 v2(147.74,87.58)
  IN1 w0.216: 148.43,73.86 148.86,73.44 148.86,68.34 152,65.2 152,64.93 151.83,64.76 151.83,64.49 152.02,64.3 152.28,64.3 152.46,64.47 152.73,64.47 152.92,64.28 152.92,64.02 152.61,63.71 152.61,63.44 152.8,63.25 153.07,63.25 153.27,63.45 153.54,63.45 153.73,63.26 153.73,62.99 153.5,62.75 153.5,62.55 153.73,62.31 153.73,55.26 151.48,53 151.48,48.88 150.57,47.97 150.57,44 151.39,43.18 151.39,40.28 151.16,40.06 150.44,40.06 150.21,40.28 150.21,41.64 v4(150.74,42.16)
  BOTTOM w0.076: v2(147.74,87.58) 148.1,87.95 U25.AM33
  BOTTOM w0.191: v4(150.74,42.16) 150.74,43.64 148.95,45.44 JDIM1.115
M_B_CKE0: length 50.3
  IN1 w0.076: v2(138.02,82.52) 138.02,81.8 138.4,81.42 138.4,79.76 137.46,78.82 137.46,75.96 135.98,74.47
  IN1 w0.216: 135.98,74.47 134.76,73.26 134.76,71.04 131.68,67.96 131.68,51.12 133.41,49.4 133.41,48.84 134.63,47.62 134.63,43.57 v4(135.45,42.75)
  BOTTOM w0.076: U25.AY49 138.39,82.89 v2(138.02,82.52)
  BOTTOM w0.191: v4(135.45,42.75) 135.27,42.93 135.27,45.25 136.35,46.33 JDIM1.73
M_B_CKE1: length 51.7
  IN1 w0.076: v2(137.99,79.9) 137.3,79.21 137.3,76.28 135.49,74.47
  IN1 w0.216: 135.49,74.47 134.24,73.22 134.24,71.25 131.16,68.17 131.16,50.91 132.8,49.27 132.8,48.71 134.1,47.41 134.1,42.12 134.75,41.47 v4(135.44,41.47)
  BOTTOM w0.076: v2(137.99,79.9) 137.99,79.97 137.6,80.37 137.6,81.08 137.19,81.48 137.19,82.83 137.32,82.96 137.32,84.31 137.51,84.5 U25.AU50
  BOTTOM w0.191: v4(135.44,41.47) 136.02,41.47 136.65,40.84 JDIM1.74
M_B_CLKN0: length 58.5
  IN1 w0.076: 144.59,78.31 144.64,78.36 144.64,79.52 144.8,79.69 144.8,84.87 144.3,85.38 144.3,86.63 144.49,86.82 144.49,87.22 v2(144.88,87.61)
  IN1 w0.14: 144.59,78.31 144.59,74.56 144.38,74.35 144.38,57.91 144.66,57.63 144.85,57.63 145.01,57.47 145.01,57 144.85,56.85 144.69,56.85 144.38,56.54 144.38,55.85 144.69,55.54 146.9,55.54 147.05,55.39 147.05,54.92 146.9,54.77 144.69,54.77 144.38,54.46 144.38,53.77 144.69,53.46 145.83,53.46 145.97,53.32 145.97,52.88 145.48,52.38 145.48,49.62 146.74,48.35 146.74,47.99 146.27,47.52 146.27,47.03 146.61,46.68 146.91,46.68 147.03,46.56 147.03,45.02 146.89,44.88 146.53,44.88 146.35,45.06 v4(146.35,45.53)
  BOTTOM w0.076: U25.AM38 145.21,87.95 v2(144.88,87.61)
  BOTTOM w0.127: JDIM1.103 145.35,46.52 145.16,46.33 145.16,45.84 144.99,45.66 144.99,44.73 145.2,44.52 145.52,44.52 145.96,44.96 146.12,44.96 146.35,45.2 v4(146.35,45.53)
M_B_CLKN1: length 56.7
  IN1 w0.076: v2(144.87,89.66) 144.87,89.17 144.8,89.1 144.71,89.1 144.26,89.55 143.96,89.55 143.78,89.38 143.78,88.99 144.24,88.53 144.24,87.9 143.9,87.57 143.9,84.88 143.71,84.69 143.71,82.27 144.42,81.55 144.42,79.91 143.72,79.22 143.72,78.36 143.67,78.31
  IN1 w0.14: v4(146.36,41.57) 146.36,41.83 146.21,41.98 145.7,41.98 145.35,42.32 145.35,48.45 144.54,49.26 144.54,52.32 143.46,53.39 143.46,74.76 143.67,74.97 143.67,78.31
  BOTTOM w0.076: U25.AK38 145.28,89.25 v2(144.87,89.66)
  BOTTOM w0.127: v4(146.36,41.57) 146.36,41.95 146.18,42.13 145.73,42.13 145.62,42.01 145.62,40.77 145.65,40.73 JDIM1.104
M_B_CLKP0: length 58.1
  IN1 w0.076: v2(144.88,86.98) 144.46,86.56 144.46,85.45 144.97,84.94 144.97,79.62 144.8,79.45 144.8,78.36 144.85,78.31
  IN1 w0.14: v4(146.36,44.26) 146.71,44.62 147,44.62 147.3,44.91 147.3,46.67 147.02,46.95 146.73,46.95 146.54,47.14 146.54,47.41 147.01,47.88 147.01,48.46 145.74,49.73 145.74,52.27 146.24,52.77 146.24,53.43 145.94,53.73 144.8,53.73 144.64,53.88 144.64,54.35 144.8,54.5 147.01,54.5 147.32,54.81 147.32,55.5 147.01,55.81 144.8,55.81 144.64,55.96 144.64,56.43 144.8,56.58 144.96,56.58 145.27,56.89 145.27,57.58 144.96,57.89 144.77,57.89 144.64,58.02 144.64,74.24 144.85,74.45 144.85,78.31
  BOTTOM w0.076: U25.AN38 145.2,87.3 v2(144.88,86.98)
  BOTTOM w0.127: JDIM1.101 144.75,46.52 144.89,46.38 144.93,46.33 144.93,45.93 144.76,45.76 144.76,44.64 145.11,44.29 145.61,44.29 146.05,44.73 146.16,44.73 146.36,44.53 v4(146.36,44.26)
M_B_CLKP1: length 56.4
  IN1 w0.076: v2(144.82,88.35) 144.82,88.76 144.19,89.39 144.03,89.39 143.95,89.31 143.95,89.06 144.4,88.6 144.4,87.84 144.07,87.5 144.07,84.81 143.88,84.62 143.88,82.33 144.59,81.62 144.59,79.85 143.89,79.15 143.89,78.36 143.94,78.31
  IN1 w0.14: v4(146.33,42.84) 146.33,42.35 146.23,42.25 145.81,42.25 145.62,42.43 145.62,48.56 144.8,49.37 144.8,52.43 143.73,53.5 143.73,74.65 143.94,74.86 143.94,78.31
  BOTTOM w0.076: U25.AL38 145.06,88.6 v2(144.82,88.35)
  BOTTOM w0.127: JDIM1.102 145.05,40.51 145.39,40.84 145.39,42.11 145.64,42.36 146.18,42.36 146.33,42.51 v4(146.33,42.84)
M_B_CS#0: length 57.4
  IN1 w0.076: v2(148.64,87.63) 148.3,87.98 148.3,88.49 148.11,88.67 148.11,89.03 147.88,89.26 147.56,89.26 147.33,89.03 147.33,88.76 147.34,88.75 147.34,85.89 147.36,85.87 147.36,85.22 146.82,84.68 146.82,78.62 147.39,78.05 147.39,76.51 147.69,76.22 148.12,75.79 148.12,73.81 148.14,73.79 148.14,73.53
  IN1 w0.216: 148.14,73.53 148.14,68.04 151.1,65.07 151.1,63.92 153.01,62.01 153.01,55.56 150.75,53.3 150.75,50.19 149.85,49.28 149.85,43.02 v4(149.65,42.82)
  BOTTOM w0.076: v2(148.64,87.63) 148.96,87.95 U25.AM32
  BOTTOM w0.191: v4(149.65,42.82) 149.65,42.41 149.01,41.77 149.01,40.85 148.65,40.49 JDIM1.114
M_B_CS#1: length 55.3
  IN1 w0.076: 148.94,74.4 148.69,74.64 148.69,76.54 148.05,77.18 148.05,83.54 148.16,83.64 148.16,84.53 149.09,85.46 149.09,87.97 148.87,88.19 148.87,88.44 149.09,88.66 149.09,88.86 149,88.94 v2(148.65,88.94)
  IN1 w0.216: 148.94,74.4 150.16,73.17 150.16,72.6 150.35,72.41 150.81,72.41 151,72.22 151,71.96 150.81,71.77 150.35,71.77 150.16,71.58 150.16,71.34 150.38,71.12 150.82,71.12 151,70.93 151,70.66 150.85,70.51 150.81,70.47 150.35,70.47 150.16,70.28 150.16,70.01 150.35,69.82 150.81,69.82 151,69.63 151,69.36 150.81,69.17 150.35,69.17 150.16,68.99 150.16,68.8 150.45,68.51 150.72,68.51 150.93,68.3 150.93,68.03 154.98,63.98 154.98,54.74 152.72,52.49 152.72,48.36 151.89,47.53 151.89,46.4 v4(152.04,46.24)
  BOTTOM w0.076: v2(148.65,88.94) 148.96,89.25 U25.AK32
  BOTTOM w0.191: v4(152.04,46.24) 151.75,46.24 151.41,45.9 151.15,45.9 150.75,46.3 JDIM1.121
M_B_DQ0: length 57.9
  IN1 w0.076: v2(132.05,86.26) 132.18,86.26 132.57,85.87 132.57,85.43 131.54,84.4 130.67,84.4 130.48,84.2 130.48,83.36 129.89,82.77 129.89,81.24 128,79.35 128,78.85 127.87,78.71
  IN1 w0.14: 127.87,78.71 120.84,71.69 120.84,58.54 120.72,58.42 119.86,58.42 119.73,58.3 119.73,58.12 119.86,58 120.72,58 120.84,57.88 120.84,57.7 120.72,57.58 119.86,57.58 119.73,57.46 119.73,51.42 120.47,50.68 120.47,48.1 121.93,46.64 121.93,42.51 122.09,42.35 122.42,42.35 v4(122.56,42.49)
  BOTTOM w0.076: U25.AP58 132.44,86.65 v2(132.05,86.26)
  BOTTOM w0.127: JDIM1.36 122.85,40.61 123.07,40.83 123.07,41.98 122.55,42.49 v4(122.56,42.49)
M_B_DQ1: length 57.2
  IN1 w0.076: v2(132.17,85.61) 131.12,84.56 130.59,84.56 130.31,84.29 130.31,83.43 129.7,82.81 129.7,81.28 127.75,79.34 127.75,79.13 127.6,78.98
  IN1 w0.14: 127.6,78.98 120.5,71.88 120.5,60.71 120.23,60.44 119.91,60.44 119.78,60.32 119.78,60.14 119.91,60.02 120.38,60.02 120.5,59.9 120.5,59.72 120.38,59.6 119.51,59.6 119.39,59.48 119.39,59.3 119.51,59.18 120.38,59.18 120.5,59.06 120.5,58.88 120.38,58.76 119.51,58.76 119.39,58.64 119.39,48.7 121.45,46.64 121.45,42.08 v4(122.56,40.97)
  BOTTOM w0.076: v2(132.17,85.61) 132.51,85.94 U25.AR58
  BOTTOM w0.127: JDIM1.34 122.25,40.67 122.55,40.97 v4(122.56,40.97)
M_B_DQ2: length 60
  IN1 w0.076: 128.94,82.26 129.11,82.42 129.11,82.97 129.77,83.63 129.77,85.47 130.31,86.01 130.31,86.46 131.77,87.92 132.6,87.92 v2(132.9,87.62)
  IN1 w0.14: 128.94,82.26 119.19,72.51 119.19,66.54 118.07,65.42 118.07,48.17 119.48,46.75 119.48,43.76 120.55,42.7 120.55,41.6 120.4,41.45 120.19,41.45 120.04,41.6 120.04,42.16 119.89,42.32 v4(119.45,42.32)
  BOTTOM w0.076: v2(132.9,87.62) 133.23,87.95 U25.AM57
  BOTTOM w0.127: v4(119.45,42.32) 118.65,41.52 JDIM1.22
M_B_DQ3: length 61.5
  IN1 w0.076: v2(132.95,88.95) 132.39,89.51 132.13,89.51 132.13,89.51 131.8,89.51 131.8,89.51 131.77,89.51 131.37,89.1 131.37,88.28 129.81,86.72 129.81,86.21 129.27,85.67 129.27,84.52 129.08,84.33
  IN1 w0.14: v4(119.45,40.86) 119.45,40.23 119.15,39.93 118.39,39.93 118.1,40.22 118.1,46.68 117.04,47.74 117.04,71.86 125.98,80.8 125.98,81.23 129.08,84.33
  BOTTOM w0.076: U25.AK57 133.25,89.25 v2(132.95,88.95)
  BOTTOM w0.127: JDIM1.24 119.25,40.67 v4(119.45,40.86)
M_B_DQ4: length 59.5
  IN1 w0.076: v2(132.07,88.32) 131.87,88.32 130.14,86.58 130.14,86.08 129.6,85.54 129.6,83.77 128.44,82.61
  IN1 w0.14: 128.44,82.61 127.91,82.08 127.91,81.71 127.59,81.39 127.22,81.39 127.02,81.19 127.02,80.87 118.85,72.7 118.85,69.76 118.73,69.64 117.85,69.64 117.73,69.51 117.73,69.34 117.85,69.22 118.73,69.22 118.85,69.09 118.85,68.92 118.73,68.8 117.85,68.8 117.73,68.67 117.73,68.5 117.85,68.38 118.73,68.38 118.85,68.26 118.85,68.08 118.73,67.96 117.85,67.96 117.73,67.84 117.73,67.66 117.85,67.54 118.73,67.54 118.85,67.42 118.85,67.24 118.73,67.12 117.85,67.12 117.73,67 117.73,66.82 117.85,66.7 118.44,66.7 118.57,66.58 118.57,66.41 118.44,66.28 117.85,66.28 117.73,66.16 117.73,48.03 119.02,46.73 v4(119.02,45.95)
  BOTTOM w0.076: U25.AL58 132.35,88.6 v2(132.07,88.32)
  BOTTOM w0.127: JDIM1.21 118.35,46.62 v4(119.02,45.95)
M_B_DQ5: length 61
  IN1 w0.076: 129.2,83.94 129.44,84.18 129.44,85.61 129.98,86.14 129.98,86.65 131.65,88.32 131.65,88.78 131.99,89.13 131.99,89.11 v2(132,89.11)
  IN1 w0.14: 129.2,83.94 126.33,81.06 126.33,80.66 118.51,72.84 118.51,72.61 118.41,72.51 118.18,72.51 118.05,72.38 118.05,72.21 118.18,72.09 118.38,72.09 118.51,71.96 118.51,71.78 118.38,71.66 117.8,71.66 117.68,71.53 117.68,71.36 117.8,71.24 118.38,71.24 118.51,71.11 118.51,70.94 118.38,70.82 117.51,70.82 117.38,70.69 117.38,70.52 117.51,70.4 118.38,70.4 118.51,70.28 118.51,70.1 118.38,69.98 117.56,69.98 117.38,69.8 117.38,47.88 118.44,46.82 118.44,44.2 118.59,44.06 118.9,44.06 119.03,44.19 v4(119.03,44.43)
  BOTTOM w0.076: v2(132,89.11) 132.13,89.25 U25.AK58
  BOTTOM w0.127: JDIM1.23 118.95,46.63 119.51,46.08 119.51,44.91 v4(119.03,44.43)
M_B_DQ6: length 58.4
  IN1 w0.076: 128.38,78.2 128.42,78.24 128.42,79.11 130.22,80.91 130.22,82.56 132.99,85.33 132.99,86.24 v2(132.9,86.33)
  IN1 w0.14: 128.38,78.2 121.53,71.35 121.53,53.54 121.41,53.42 120.54,53.42 120.42,53.3 120.42,53.12 120.54,53 121.41,53 121.53,52.88 121.53,52.7 121.41,52.58 120.54,52.58 120.42,52.46 120.42,52.28 120.54,52.16 121.41,52.16 121.53,52.04 121.53,48.01 123.08,46.47 123.08,43.2 122.94,43.06 122.7,43.06 122.56,43.21 v4(122.56,44.45)
  BOTTOM w0.076: U25.AR57 133.24,86 v2(132.9,86.33)
  BOTTOM w0.127: v4(122.56,44.45) 121.95,45.06 JDIM1.33
M_B_DQ7: length 59.5
  IN1 w0.076: v2(132.9,86.97) 132.62,86.97 132.47,86.82 132.47,86.21 132.83,85.85 132.83,85.4 130.06,82.63 130.06,81 128.22,79.16 128.22,78.52 128.14,78.44
  IN1 w0.14: 128.14,78.44 121.19,71.49 121.19,57.24 121.06,57.11 120.67,57.11 120.55,56.99 120.55,56.82 120.67,56.7 121.06,56.7 121.19,56.57 121.19,56.4 121.06,56.28 120.29,56.28 120.17,56.15 120.17,55.98 120.29,55.86 121.06,55.86 121.19,55.73 121.19,55.56 121.06,55.44 120.2,55.44 120.08,55.32 120.08,55.14 120.2,55.02 121.06,55.02 121.19,54.9 121.19,54.72 121.06,54.6 120.26,54.6 120.14,54.48 120.14,54.3 120.26,54.18 121.06,54.18 121.19,54.06 121.19,53.88 121.06,53.76 120.2,53.76 120.08,53.64 120.08,51.56 120.66,50.98 121.06,50.98 121.18,50.86 121.18,50.68 121.06,50.56 120.94,50.56 120.81,50.44 120.81,50.27 120.94,50.14 121.02,50.14 121.16,50 121.16,49.86 121.02,49.72 120.94,49.72 120.81,49.6 120.81,49.43 120.94,49.3 121.02,49.3 121.16,49.16 121.16,49.02 121.02,48.89 120.94,48.89 120.81,48.76 120.81,48.59 120.94,48.47 121.11,48.47 121.19,48.39 121.19,47.87 122.56,46.5 v4(122.56,45.9)
  BOTTOM w0.076: U25.AN57 133.23,87.3 v2(132.9,86.97)
  BOTTOM w0.127: v4(122.56,45.9) 123.01,45.9 123.11,46 123.11,46.15 122.55,46.71 JDIM1.35
M_B_DQ8: length 54.3
  IN1 w0.076: v2(133.88,86.32) 133.88,86.24 133.49,85.84 133.49,85.12 130.72,82.36 130.72,80.58 129.06,78.92 129.06,77.78 128.95,77.67 128.95,77.62
  IN1 w0.14: 128.95,77.62 128.95,76.59 127.23,74.86 126.75,74.86 123.28,71.39 123.28,70.85 123.15,70.72 122.86,70.72 122.74,70.6 122.74,70.43 122.86,70.3 123.15,70.3 123.28,70.18 123.28,70.01 123.15,69.89 122.86,69.89 122.74,69.76 122.74,69.59 122.86,69.47 123.15,69.47 123.28,69.34 123.28,69.17 123.15,69.05 122.86,69.05 122.74,68.92 122.74,68.75 122.86,68.63 123.15,68.63 123.28,68.51 123.28,68.33 123.15,68.21 122.86,68.21 122.74,68.09 122.74,67.91 122.86,67.79 123.15,67.79 123.28,67.67 123.28,67.49 123.15,67.37 122.86,67.37 122.74,67.25 122.74,67.07 122.86,66.95 123.15,66.95 123.28,66.83 123.28,66.66 123.15,66.53 122.86,66.53 122.74,66.41 122.74,66.24 122.86,66.11 123.15,66.11 123.28,65.99 123.28,65.82 123.15,65.69 122.86,65.69 122.74,65.57 122.74,65.4 122.86,65.28 123.15,65.28 123.28,65.15 123.28,64.98 123.15,64.86 122.85,64.86 122.74,64.74 122.74,48.51 124.61,46.64 124.61,46.07 v4(124.6,46.07)
  BOTTOM w0.076: v2(133.88,86.32) 133.88,86.43 134.09,86.65 U25.AP55
  BOTTOM w0.127: v4(124.6,46.07) 124.36,46.07 124.2,46.23 124.2,46.46 124.35,46.6 JDIM1.41
M_B_DQ9: length 53.6
  IN1 w0.076: v2(133.88,85.65) 133.88,85.28 130.88,82.29 130.88,80.51 129.24,78.87 129.24,77.33
  IN1 w0.14: 129.24,77.33 129.24,76.54 127.33,74.62 126.99,74.62 123.62,71.24 123.62,64.64 123.5,64.52 123.21,64.52 123.09,64.39 123.09,64.22 123.21,64.1 123.5,64.1 123.62,63.98 123.62,63.8 123.5,63.68 123.22,63.68 123.09,63.56 123.09,63.38 123.22,63.26 123.5,63.26 123.62,63.14 123.62,62.96 123.5,62.84 123.18,62.84 123.08,62.74 123.08,62.54 123.2,62.42 123.5,62.42 123.62,62.3 123.62,62.13 123.5,62 123.24,62 123.08,61.84 123.08,48.66 125.07,46.67 125.07,44.68 124.92,44.53 v4(124.6,44.53)
  BOTTOM w0.076: U25.AR55 134.23,86 v2(133.88,85.65)
  BOTTOM w0.127: JDIM1.39 123.75,45.31 124.53,44.53 v4(124.6,44.53)
M_B_DQ10: length 56.5
  IN1 w0.076: v2(135.78,87.64) 135.78,87.68 135.71,87.76 135.53,87.76 135.41,87.63 135.41,86.81 135.82,86.4 135.82,85.22 133.37,82.78 133.37,82.58 133.63,82.32 133.63,81.55 133.15,81.08 132.87,81.08 132.76,80.98 132.76,80.8 132.99,80.57 132.99,80.32 132.76,80.09 132.76,79.93 132.97,79.73 132.97,79.53 132.76,79.32 132.76,79.07 132.97,78.87 132.97,78.69 132.87,78.59 132.5,78.59 131.58,77.67 131.58,76.77 131.72,76.63 131.72,76.38 131.58,76.24 131.58,75.67 131.55,75.64
  IN1 w0.14: v4(129.01,45.87) 128.56,45.43 128.4,45.43 128.29,45.53 128.29,45.9 128.6,46.2 128.6,46.44 125.98,49.06 125.98,51.5 125.42,52.07 125.42,57.97 125.54,58.09 125.83,58.09 125.96,58.22 125.96,58.39 125.83,58.51 125.54,58.51 125.42,58.64 125.42,58.81 125.54,58.93 125.83,58.93 125.96,59.06 125.96,59.23 125.83,59.35 125.54,59.35 125.42,59.47 125.42,59.65 125.54,59.77 125.83,59.77 125.96,59.89 125.96,60.07 125.83,60.19 125.54,60.19 125.42,60.31 125.42,60.49 125.54,60.61 125.83,60.61 125.96,60.73 125.96,70.04 131.55,75.64
  BOTTOM w0.076: v2(135.78,87.64) 135.47,87.95 U25.AM54
  BOTTOM w0.127: JDIM1.53 127.95,46.24 128.32,45.87 v4(129.01,45.87)
