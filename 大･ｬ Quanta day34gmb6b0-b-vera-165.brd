# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V on TOP (solid shape): 200.63,43.96 200.63,42.07 200.16,41.6 199.3,41.6 199.3,41.59 199.3,41.41 199.3,41.4 200.16,41.4 200.24,41.33 200.24,41.18 200.16,41.1 199.29,41.1 199.29,40.91 199.3,40.9 200.16,40.9 200.23,40.83 200.23,40.67 200.16,40.6 199.3,40.6 199.29,40.58 198.73,40.58 198.35,40.96 197.88,40.96 197.65,41.18 197.65,41.83 197.24,42.25 197.24,42.87 197.4,43.03 198.12,43.03 198.59,43.5 198.59,44.63 198.21,45.01 197.41,45.01 197.22,45.19 197.22,45.66 197.39,45.82 198.76,45.82
+5V on TOP (solid shape): 182.6,26.47 183.16,26.47 183.54,26.09 185.95,26.09 186.14,26.28 187.03,26.28 187.35,25.96 187.35,24.01 188.95,22.41 188.93,22.38 188.92,22.11 189.09,21.89 189.1,21.89 189.13,21.84 189.13,21.51 189,21.39 187.09,21.39 186.92,21.56 186.92,22.96 186.71,23.16 186.71,23.3 186.49,23.52 186.36,23.52 186.01,23.87 185.55,23.87 185.54,23.87 185.41,23.9 185.27,23.87 185.26,23.87 185.09,23.87 184.72,23.5 184.72,22.95 184.43,22.66 183.79,22.66 183.67,22.78 183.67,23.8 183.28,24.18 182.54,24.18 182.24,24.48 182.24,26.29 182.42,26.47
+5V on BOTTOM (solid shape): 67.62,174.21 67.62,173.51 66.8,172.69 64.86,172.69 64.77,172.78 64.77,173.54 64.87,173.65 66.32,173.65 66.71,174.04 66.71,174.23 66.94,174.46 67.37,174.46
+5V on BOTTOM (solid shape): 194.46,92.25 194.46,91.49 193.32,90.35 192.19,90.35 192.19,90.35 191.46,90.35 190.9,90.91 190.9,92.89 191.16,93.14 193.57,93.14
+5V on BOTTOM (solid shape): 80.16,64.44 80.16,64.31 78.38,62.54 78.13,62.54 78.12,62.54 77.96,62.56 77.79,62.54 77.79,62.54 77.62,62.54 77.13,62.04 76.82,62.04 75.68,60.9 75.67,60.89 75.65,60.88 75.08,60.88 74.83,61.14 74.83,62.15 75.96,63.29 76.03,63.32 76.1,63.29 76.55,62.97 76.85,63.43 76.85,63.47 76.84,63.5 76.84,63.53 76.86,63.55 76.91,63.6 77.32,63.6 77.4,63.68 77.97,64.24 78.41,64.69 79.91,64.69
+5V on IN1 (solid shape): outline of 222 points within 188.39,78.87 194.14,91.75
+5V on IN1 (solid shape): outline of 637 points within 67.45,21.89 78.74,45.39
+5V on IN2 (solid shape): outline of 1786 points within 19.23,27.74 56.67,90.22
+5V on SVCC (solid shape): outline of 958 points within 55.78,2.03 203.77,80.95
+5V_AMP on IN1 (solid shape): outline of 350 points within 189.91,12.88 199.67,20.3
+5V_AVDD on TOP (solid shape): 189.11,20.9 189.11,18.73 189.25,18.59 189.25,17.96 189.76,17.45 189.76,16.94 189.63,16.82 188.82,16.82 188.74,16.9 188.75,16.93 188.77,17.21 188.59,17.43 188.59,17.75 188.6,17.76 188.58,18.04 188.36,18.22 188.35,18.23 187.6,18.97 186.97,18.97 186.71,19.23 186.71,20.12 187.6,21.01 189,21.01
+5V_CAM_C on TOP (solid shape): 69,178.4 69,176.73 68.92,176.65 68.28,176.65 68.2,176.73 68.2,176.9 68.2,176.9 68.2,177.41 68.7,177.41 68.7,178.24 68.5,178.24 68.5,177.41 68.2,177.41 68.2,178.28 67.97,178.5 66.28,178.5 66.18,178.6 66.18,179.13 66.25,179.21 68.19,179.21
+5V_CAM_C on BOTTOM (solid shape): 67.57,179.06 67.57,178.64 67.47,178.55 66.71,178.55 66.3,178.14 66.3,174.61 66.16,174.47 62.75,174.47 62.6,174.62 62.6,176.61 62.65,176.68 62.69,176.77 62.69,176.78 62.72,176.81 64.93,176.81 65.24,177.12 65.24,178.93 65.52,179.21 67.42,179.21
+5V_DVDD on TOP (solid shape): 183.41,23.67 183.41,22.28 183.79,21.9 183.79,19.74 183.92,19.61 183.92,18.97 183.79,18.85 183.41,18.85 183.28,18.72 183.28,18.59 183.21,18.52 182.95,18.52 182.78,18.69 182.78,19.2 182.52,19.46 182.52,21.39 182.27,21.64 182.27,23.8 182.4,23.93 183.16,23.93
+5V_HDMIC on TOP (solid shape): 19.33,91.87 19.33,90.23 19.19,90.09 17.35,90.09 17.15,90.15 16.95,90.09 15.75,90.09 15.62,90.22 15.62,91.26 15.72,91.36 17.42,91.36 18.18,92.13 19.07,92.13
+5V_HDMIC on BOTTOM (solid shape): outline of 163 points within 11.45,83.87 21.23,90.73
+5V_LED_KBLIGHT on TOP (solid shape): 173.9,139.17 173.9,138.69 173.8,138.59 172.5,138.59 172.42,138.52 172.42,138.28 172.5,138.21 173.81,138.21 173.95,138.06 173.95,137.75 173.8,137.59 172.42,137.59 171.98,137.16 171.98,136.45 171.12,135.59 167.21,135.59 167.04,135.76 167.04,137.09 167.28,137.33 170.21,137.33 172.11,139.24 173.84,139.24
+5V_ODD on TOP (solid shape): outline of 162 points within 192.17,85.4 196.53,95.56
+5V_ODD on BOTTOM (solid shape): outline of 123 points within 191.22,93.36 201.32,101.19
+5V_S2 on TOP (solid shape): 69.8,44.96 69.81,44.93 69.79,44.86 69.76,44.8 69.74,44.75 69.72,44.69 69.72,44.63 69.72,44.57 69.74,44.51 69.76,44.45 69.79,44.4 69.82,44.35 69.86,44.31 69.91,44.27 69.95,44.25 69.98,44.23 70,44.2 70,42.22 69.75,41.96 69.6,41.96 69.58,41.98 69.53,42.01 69.47,42.04 69.41,42.05 69.35,42.06 69.28,42.06 69.22,42.05 69.16,42.04 69.1,42.01 69.05,41.98 69.03,41.96 69.01,41.96 68.69,41.65 67.4,41.65 67.33,41.71 67.33,41.84 68.1,41.84 68.1,42.05 67.45,42.05 67.45,41.84 67.33,41.84 67.33,44.25 67.46,44.37 68.22,44.37 68.98,45.14 69.62,45.14
+5V_USBP0 on TOP (solid shape): 19.14,52.18 20.04,52.18 20.22,52.01 20.22,50.63 20.05,50.47 17.28,50.47 17.17,50.58 17.17,52.5 17.3,52.63 18.69,52.63
+5V_USBP0 on BOTTOM (solid shape): outline of 169 points within 14.92,46.66 26.87,53.26
+5V_USBP0 on SVCC (solid shape): 16.99,53.34 17.07,53.28 17.17,53.26 21.03,53.26 21.49,52.8 21.49,51.21 21.19,50.92 20.96,50.81 20.85,50.58 20.67,50.4 20.62,50.31 20.6,50.21 20.6,47.25 20.11,46.76 15.39,46.76 14.86,47.3 14.8,47.34 14.72,47.37 14.72,50.27 14.74,50.38 14.74,50.49 14.74,53.5 14.73,53.63 14.71,53.76 14.72,53.86 14.72,53.95 14.72,54.16 14.97,54.4 15.93,54.4
+5V_USBP1 on TOP (solid shape): 26.21,77.47 26.21,75.95 26.06,75.8 25.83,75.8 25.66,75.63 25.53,75.5 25.53,74.89 25.46,74.82 24.39,74.82 24.38,74.83 24.38,76.45 24.33,76.51 24.33,77.5 24.46,77.62 26.06,77.62
+5V_USBP1 on BOTTOM (solid shape): outline of 194 points within 14.88,53.77 26.69,65.08
+5V_USBP1 on IN1 (solid shape): outline of 561 points within 17.52,54.13 26.34,78.32
+5V_USBP1 on SVCC (solid shape): 15.17,65.58 15.2,65.58 15.41,65.58 17.17,63.83 17.17,62.66 17.19,62.57 17.24,62.49 21.49,57.99 21.49,54.17 21.14,53.77 17.27,53.77 16.21,54.84 16.13,54.89 16.02,54.91 14.95,54.91 14.72,55.14 14.72,65.14 14.74,65.15
+5VPCU on BOTTOM (solid shape): 45.49,49.45 45.49,49.33 46.86,47.96 46.86,44.76 46.71,44.6 46.03,44.6 45.89,44.74 45.89,47.27 45.36,47.8 45.36,48.06 44.88,48.54 44.37,48.54 44.28,48.63 44.27,48.65 44,48.89 43.65,48.79 42.34,48.79 42.34,48.79 42.34,49.15 42.36,49.18 42.39,49.2 43.63,49.2 44.14,49.71 45.24,49.71
+5VS5 on TOP (solid shape): 22.13,76.24 22.13,74.82 22.13,74.82 20.92,74.82 20.3,75.43 19.38,75.43 19.29,75.34 19.29,75.15 19.14,75 18.86,75 18.84,75.01 17.78,75.01 17.55,75.24 17.55,75.77 17.77,76 19.58,76 19.84,75.93 20.1,75.99 20.11,76 20.17,76 20.63,76.46 21.92,76.46
+5VS5 on TOP (solid shape): 66.06,44.12 66.06,43.99 66.2,43.86 66.2,43.16 66.06,43.02 66.02,42.98 66,42.93 65.98,42.87 65.97,42.81 65.97,42.76 65.97,42.7 65.99,42.64 66.01,42.59 66.04,42.54 66.06,42.52 66.06,41.71 66,41.65 65.11,41.65 65.05,41.58 64.67,41.58 64.4,41.84 65.95,41.84 65.95,42.05 65.3,42.05 65.3,41.84 64.4,41.84 64.03,42.22 64.03,43.36 65.05,44.37 65.81,44.37
+5VS5 on TOP (solid shape): 90.3,87.89 90.3,87.5 90.75,87.05 90.75,86.33 91.1,85.99 91.1,85.69 91.4,85.4 91.54,85.39 92.03,85.39 92.06,85.38 92.07,85.34 92.07,85.15 92.06,85.11 92.02,85.1 90.97,85.1 90.88,85.23 90.74,85.3 90.26,85.78 89.97,85.78 89.81,85.93 89.81,86.54 89.56,86.79 89.18,86.79 89.08,86.89 89.08,87.91 89.23,88.06 90.13,88.06
+5VS5 on TOP (solid shape): 57,168.25 57,164.98 56.81,164.79 52.34,164.79 52.16,164.97 52.16,165.42 55.77,165.42 55.77,165.73 54.98,165.73 54.98,165.42 53.37,165.42 53.37,165.73 52.58,165.73 52.58,165.42 52.16,165.42 52.16,166.9 52.36,167.1 54.2,167.1 54.49,166.81 54.81,166.81 55.23,167.23 55.23,168.29 55.38,168.44 56.82,168.44
+5VS5 on TOP (solid shape): 200.22,22.16 201.05,22.16 201.32,21.9 201.32,19.99 200.94,19.61 198.55,19.61 198.5,19.66 198.5,19.86 198.55,19.91 199.82,19.91 199.85,19.94 199.85,20.09 199.82,20.12 198.6,20.12 198.47,20.24 198.47,20.36 198.49,20.39 198.52,20.41 199.83,20.41 199.83,20.61 198.52,20.61 198.49,20.63 198.47,20.66 198.47,20.85 198.49,20.89 198.52,20.9 199.82,20.9 199.82,21.12 198.52,21.12 198.49,21.14 198.47,21.17 198.47,21.36 198.49,21.4 198.52,21.41 199.8,21.41 199.8,21.61 198.52,21.61 198.49,21.62 198.47,21.66 198.47,21.86 198.49,21.9 198.52,21.91 199.81,21.91 199.81,22.11 198.52,22.11 198.49,22.13 198.47,22.16 198.47,22.28 198.6,22.4 199.98,22.4
+5VS5 on TOP (solid shape): outline of 411 points within 98.93,14.91 117.37,39.42
+5VS5 on BOTTOM (solid shape): 194.11,71.4 194.11,71.02 194.33,70.79 194.33,70.33 194.23,70.23 193.98,70.23 193.8,70.05 193.8,70 193.8,70 193.8,69.57 193.78,69.53 193.74,69.52 193.57,69.52 193.55,69.55 193.55,70.03 193.44,70.13 193.44,70.92 193.29,71.07 193.29,71.48 193.37,71.55 193.95,71.55
+5VS5 on BOTTOM (solid shape): outline of 160 points within 19.59,75.24 26.69,80.06
+5VS5 on BOTTOM (solid shape): outline of 177 points within 86.23,4.9 123.34,14.15
+5VS5 on BOTTOM (solid shape): outline of 352 points within 18.04,41.48 31.23,47.31
+5VS5 on IN1 (solid shape): 187.73,23.66 187.73,23.29 186.81,22.38 185.66,22.38 185.47,22.56 185.47,23.13 185.95,23.13 185.96,23.07 185.97,23.02 185.99,22.96 186.02,22.92 186.06,22.87 186.1,22.84 186.15,22.81 186.2,22.78 186.25,22.77 186.3,22.76 186.36,22.76 186.42,22.77 186.47,22.78 186.52,22.81 186.57,22.84 186.61,22.87 186.64,22.92 186.67,22.96 186.69,23.02 186.71,23.07 186.71,23.13 186.71,23.18 186.7,23.24 186.68,23.29 186.66,23.34 186.63,23.38 186.59,23.42 186.54,23.46 186.49,23.49 186.44,23.51 186.39,23.52 186.33,23.52 186.28,23.52 186.22,23.51 186.17,23.49 186.12,23.46 186.08,23.42 186.04,23.38 186.01,23.34 185.98,23.29 185.96,23.24 185.95,23.18 185.95,23.13 185.47,23.13 185.47,23.66 185.65,23.84 187.55,23.84
+5VS5 on IN1 (solid shape): outline of 108 points within 191.67,28.84 200.67,33.84
+5VS5 on IN2 (solid shape): outline of 426 points within 196.11,19.61 203,33.96
+5VS5 on IN2 (solid shape): outline of 2644 points within 115.57,5.26 193.44,32.93
+5VS5 on IN2 (solid shape): outline of 3973 points within 24.83,10.51 88.47,79.51
+5VS5_S on BOTTOM (solid shape): outline of 101 points within 28.96,39.8 43.15,45.77
+AVCC on TOP (solid shape): 181.89,37.77 181.89,36.73 182.75,35.87 182.75,33.43 182.65,33.33 180.87,33.33 180.72,33.48 180.72,37.16 180.49,37.39 180.49,37.9 180.62,38.02 181.63,38.02
+VCC_CORE on TOP (solid shape): outline of 2531 points within 110.89,90.98 155.09,115.77
+VCC_CORE on BOTTOM (solid shape): 114.35,112.95 117.88,112.95 118.26,112.57 118.26,106.11 118.12,105.97 118.12,105.21 118.12,105.21 118.12,103.48 115.15,100.51 111.66,100.51 111.5,100.66 111.5,102.64 112.55,103.68 112.55,105.33 112.8,105.59 114.45,105.59 114.49,105.57 114.5,105.54 114.5,105.52 115.1,105.52 115.1,106.16 114.5,106.16 114.5,106.15 114.49,106.11 114.45,106.1 112.8,106.1 112.55,106.35 112.55,111.46 112.7,111.61 112.71,111.61 112.71,112.87 113.03,113.18 114.12,113.18
+VCC_CORE on BOTTOM (solid shape): outline of 1508 points within 132.4,90.92 155.47,103.73
+VCC_CORE on IN1 (solid shape): outline of 157 points within 111.44,101.28 127.76,110.39
+VCC_CORE on IN2 (solid shape): outline of 3147 points within 111.43,91.87 154.11,116.85
+VCC_CORE on SVCC (solid shape): 127.55,110.03 127.64,109.64 128.04,109.55 128.06,109.52 128.15,109.13 128.55,109.04 128.57,109.02 128.66,108.62 129.06,108.53 131.6,105.99 131.6,104.07 131.61,103.97 131.67,103.88 132.3,103.25 132.39,103.19 132.5,103.18 154.13,103.18 154.49,102.82 154.49,100.03 154.48,100 154.48,99.97 154.48,91.85 154.41,91.79 153.96,91.8 153.82,91.36 153.53,91.36 153.34,91.55 153.09,91.62 143.82,91.62 143.63,91.58 143.46,91.47 142.85,90.86 133.11,90.86 132.24,91.72 132.07,91.83 131.88,91.87 127.61,91.87 127,92.49 126.83,92.6 126.64,92.63 115.68,92.63 113.43,94.88 113.43,96.31 113.4,96.51 113.29,96.68 112.55,97.42 112.55,100.38 112.51,100.57 112.4,100.74 111.53,101.61 111.53,103.09 112.14,103.7 112.25,103.87 112.29,104.07 112.29,105.56 112.42,105.84 112.29,106.13 112.29,110.97 114.03,112.7 115.59,112.7 115.79,112.74 115.95,112.85 117.33,114.22 123.36,114.22
+VCC_TS on TOP (solid shape): 67.49,178.13 67.49,176.86 69.62,174.74 69.62,174.09 69.45,173.92 69.22,173.92 68.67,174.47 68.34,174.47 68.17,174.64 68.17,175.32 67.63,175.87 67.63,176.07 67.29,176.4 67.29,177.73 67.2,177.83 67.2,178.13 67.26,178.19 67.43,178.19
+VCC_TS on TOP (solid shape): 45.68,180.04 45.68,178.82 45.51,178.64 45.15,178.64 44.91,178.73 44.66,178.64 44.62,178.64 44.62,178.65 44.03,178.65 43.97,178.71 43.97,179.76 44.37,180.16 45.56,180.16
+VCC_TS on BOTTOM (solid shape): 48.68,181.15 48.68,179.98 48.57,179.87 47.87,179.87 47.83,179.88 47.82,179.89 47.69,179.98 47.53,180.01 47.38,179.98 47.25,179.89 47.2,179.9 47.16,179.92 47.04,179.99 46.9,180.01 46.74,179.98 46.59,179.87 46.56,179.87 46.02,179.87 45.6,179.45 45.6,179.18 45.34,178.93 44.86,178.93 44.71,179.07 44.71,179.49 44.52,179.68 44.52,181.03 44.71,181.22 45.15,181.22 45.15,181.22 46.46,181.22 46.71,181.47 48.37,181.47
+VIN on TOP (solid shape): 104.49,186.33 104.49,183.97 104.27,183.74 103.35,183.74 102.87,183.26 102.87,180.94 102.72,180.79 102.72,178.46 100.46,178.46 100.11,178.8 100.11,184.14 100.84,184.86 102.44,184.86 104.04,186.46 104.37,186.46
+VIN on TOP (solid shape): 195.35,51.24 195.35,49.07 195.22,48.95 193.32,48.95 193.06,49.2 193.06,49.96 193.16,50.06 193.71,50.06 194.15,50.5 194.15,51.18 194.4,51.43 195.16,51.43
+VIN on TOP (solid shape): 64.51,179.76 64.51,179.35 64.41,179.25 64.29,179.25 64,178.96 64,174.99 63.73,174.73 63.03,174.73 63.03,174.73 62.54,174.73 62.36,174.54 62.13,174.54 62.02,174.65 62.02,175.03 62.84,175.85 62.84,176.43 63.2,176.79 63.2,177.41 63.7,177.41 63.7,178.24 63.5,178.24 63.5,177.41 63.2,177.41 63.2,179.31 63.75,179.86 64.41,179.86
+VIN on TOP (solid shape): 198.78,62.66 198.78,61.49 198.94,61.18 199.37,61.12 199.41,61.04 199.41,60.25 199.16,60 197,60 196.87,60.12 196.87,61.18 196.88,61.2 196.91,61.23 196.91,62.57 197.13,62.79 198.65,62.79
+VIN on BOTTOM (solid shape): outline of 111 points within 193.93,48.82 201.01,63.53
+VIN on BOTTOM (solid shape): outline of 2621 points within 35.25,51.36 194.33,175.13
+VIN on IN1 (solid shape): 75.21,180.14 75.21,176.33 75.08,176.2 74.45,176.2 74.06,176.58 74.06,178.36 73.22,179.2 73.22,179.21 72.88,179.5 72.5,179.28 72.49,179.25 71.71,179.25 71.7,179.28 71.35,179.5 71,179.28 70.99,179.25 64.29,179.25 64.03,178.99 64.03,178.49 63.9,178.36 63.27,178.36 63.14,178.49 63.14,179.88 63.78,180.52 74.83,180.52
+VIN on SVCC (solid shape): 102.72,183.33 102.72,174.21 101.43,172.93 101.42,172.92 100.99,172.49 88.22,172.49 87.91,172.8 87.91,173.93 87.87,174.13 87.76,174.3 86.49,175.57 86.32,175.68 86.12,175.72 73.51,175.72 73.13,176.11 73.13,178.25 73.76,178.87 92.47,178.87 92.67,178.9 92.84,179.02 94,180.17 94.16,180.25 94.28,180.39 96.82,180.39 97.02,180.43 97.18,180.54 98.68,182.04 98.79,182.21 98.83,182.4 98.83,183.61 99.29,184.07 101.97,184.07
+VIN_1.05V on TOP (solid shape): 194.87,65.93 194.89,65.9 194.93,65.85 194.96,65.81 195.01,65.77 195.06,65.75 195.11,65.73 195.17,65.71 195.22,65.71 195.28,65.71 195.33,65.73 195.39,65.75 195.44,65.77 195.48,65.81 195.52,65.85 195.55,65.9 195.57,65.93 195.62,65.96 197,65.96 197.13,65.84 197.13,63.37 196.59,62.83 196.59,62.63 196.59,61.23 196.49,61.14 194.84,61.14 194.21,61.77 194.21,63.18 195.81,63.18 195.81,63.13 195.83,63.07 195.85,63.02 195.88,62.97 195.91,62.93 195.95,62.89 196,62.86 196.05,62.84 196.1,62.82 196.16,62.81 196.22,62.81 196.27,62.82 196.32,62.84 196.37,62.86 196.42,62.89 196.46,62.93 196.5,62.97 196.53,63.02 196.55,63.07 196.56,63.13 196.57,63.18 196.57,63.24 196.56,63.29 196.54,63.34 196.51,63.39 196.48,63.44 196.44,63.48 196.4,63.51 196.35,63.54 196.3,63.56 196.24,63.57 196.19,63.58 196.13,63.57 196.08,63.56 196.03,63.54 195.98,63.51 195.93,63.48 195.89,63.44 195.86,63.39 195.84,63.34 195.82,63.29 195.81,63.24 195.81,63.18 194.21,63.18 194.21,64.92 194.05,65.08 193.5,65.08 193.29,65.28 193.29,65.79 193.47,65.96 194.83,65.96
+VIN_1.05V on BOTTOM (solid shape): 194.28,69.42 194.36,69.34 194.74,69.34 194.77,69.32 194.77,66.62 194.71,66.57 194.46,66.57 194.36,66.47 194.36,65.79 195.07,65.07 195.07,63.67 194.89,63.49 193.87,63.49 193.39,63.96 193.39,65.13 193.37,65.15 193.37,69.3 193.42,69.34 193.98,69.34 194.03,69.39 194.03,69.54 194.04,69.54 194.04,70 194.28,70
+VIN_3VS5 on BOTTOM (solid shape): 51.71,57.3 51.71,55.45 53.36,53.8 53.36,51.1 53.34,51.08 51.26,51.08 50.34,51.99 47.2,51.99 47.02,52.17 47.02,53.15 47.35,53.47 48.08,53.47 48.28,53.68 48.28,55.3 49.05,56.06 49.05,57.02 49.57,57.55 51.47,57.55
+VIN_5VS5 on BOTTOM (solid shape): 42.28,57.94 42.28,57.55 44.02,57.55 44.09,57.48 44.09,49.96 43.46,49.33 42.49,49.33 42.46,49.34 42.44,49.38 42.44,55.55 42.06,55.93 41.43,55.93 41.05,56.31 41.05,57.96 41.12,58.04 42.17,58.04
+VIN_DDR on BOTTOM (solid shape): 97.36,58.5 97.36,56.21 97.05,55.91 96.14,55.91 95.83,55.6 95.83,50.93 95.52,50.61 93.07,50.61 92.93,50.76 92.93,51.02 92.94,51.03 92.94,54.53 94.16,55.76 94.16,57.43 95.38,57.43 95.68,57.73 95.68,58.5 95.83,58.65 97.2,58.65
+VIN_VCC_CORE on TOP (solid shape): 109.64,91.1 109.64,87.02 109.42,86.81 101.86,86.81 101.75,86.92 100.42,86.92 99.83,87.52 99.46,87.52 99.35,87.41 98.95,87.41 98.81,87.55 98.81,87.83 98.75,87.98 98.59,88.07 98.58,88.11 98.58,90.73 98.7,90.86 99.21,90.86 99.72,91.36 109.37,91.36
+VIN_VCC_CORE on BOTTOM (solid shape): 104.4,91.32 109.33,91.32 109.62,91.02 109.62,86.92 108.48,85.78 103.15,85.78 103.02,85.9 103.02,86.41 102.16,87.27 102.16,88.48 101.71,88.48 99.77,90.43 99.77,91.34 100.17,91.75 103.97,91.75
AGND on TOP (solid shape): 184.05,7.54 184.05,6.02 183.92,5.89 183.54,5.89 183.41,5.77 183.41,5.13 183.31,5.03 182.37,5.03 182.27,5.13 182.27,7.04 182.88,7.65 183.11,7.65 183.13,7.67 183.92,7.67
AGND on TOP (solid shape): 188.36,7.29 188.36,6.76 188.3,6.69 188.27,6.68 188.24,6.68 187.78,6.59 187.81,6.12 188.06,5.87 188.06,5.23 187.96,5.13 187.09,5.13 186.97,5.26 186.97,6.4 186.84,6.53 185.7,6.53 185.57,6.66 185.57,7.54 185.7,7.67 187.98,7.67
AGND on TOP (solid shape): 191.46,19.93 191.65,19.74 195.86,19.74 197.38,18.21 197.38,16.94 197.33,16.89 197.32,16.89 196.1,15.67 193.19,15.67 192.94,15.93 192.94,16.69 192.81,16.82 192.17,16.82 192.05,16.94 192.05,17.58 191.79,17.83 191.29,17.83 190.4,16.94 190.07,16.94 189.94,17.07 189.94,17.53 189.51,17.96 189.51,19.7 189.24,19.97 189.24,20.03 189.79,20.03 189.79,19.97 189.81,19.92 189.83,19.87 189.86,19.82 189.89,19.78 189.93,19.74 189.98,19.71 190.03,19.68 190.08,19.67 190.14,19.66 190.2,19.66 190.25,19.67 190.3,19.68 190.36,19.71 190.4,19.74 190.44,19.78 190.48,19.82 190.51,19.87 190.53,19.92 190.54,19.97 190.55,20.03 190.55,20.08 190.54,20.14 190.52,20.19 190.49,20.24 190.46,20.29 190.42,20.33 190.38,20.36 190.33,20.39 190.28,20.41 190.22,20.42 190.17,20.42 190.11,20.42 190.06,20.41 190.01,20.39 189.96,20.36 189.91,20.33 189.87,20.29 189.84,20.24 189.82,20.19 189.8,20.14 189.79,20.08 189.79,20.03 189.24,20.03 189.24,20.59 189.61,20.96 190.43,20.96
AGND on TOP (solid shape): 177.95,6.91 177.95,5.13 178.2,4.88 178.43,4.88 178.7,4.61 179.24,4.61 179.24,5.15 178.97,5.42 178.97,5.51 179.09,5.64 180.74,5.64 180.87,5.51 180.87,5.22 180.86,5.19 180.83,5.18 180.56,4.86 180.73,4.49 180.84,4.44 180.96,4.43 181.37,4.02 189.42,4.02 190.47,5.08 191.03,5.08 191.27,4.84 191.27,3.01 176.37,3.01 150.39,3.01 150.39,3.99 156.92,3.99 157.17,3.73 161.31,3.73 161.57,3.99 175.13,3.99 176.3,5.16 176.3,6.4 176.93,7.04 177.82,7.04
AGND on BOTTOM (solid shape): outline of 262 points within 150.39,3.01 200.81,19.58
AGND on SGND (solid shape): outline of 113 points within 150.39,3.01 200.81,21.89
AGND on IN1 (solid shape): 191.22,4.02 191.25,4.01 191.27,3.97 191.27,3.06 191.25,3.02 191.22,3.01 176.37,3.01 150.44,3.01 150.41,3.02 150.39,3.06 150.39,3.94 150.41,3.97 150.44,3.99 173.91,3.99 173.95,4.02
AGND on IN1 (solid shape): 181.63,10.41 181.64,10.39 181.64,10.38 181.69,10.17 181.89,10.08 182.39,10.08 186.68,10.08 186.77,10.02 186.75,9.91 186.45,9.61 181.4,9.61 177.11,5.32 175.49,5.32 175.4,5.38 175.41,5.48 175.41,6.61 175.41,6.62 175.44,6.76 175.41,6.9 175.41,6.91 175.41,7.74 175.84,8.18 175.91,8.18 178.31,8.18 178.99,8.87 178.99,9.24 179.2,9.45 179.6,9.45 179.7,9.47 179.78,9.52 180.16,9.9 180.22,9.99 180.24,10.09 180.24,10.34 180.23,10.39 180.24,10.41 180.49,10.67 181.38,10.67
AGND on IN1 (solid shape): outline of 475 points within 177.72,4.53 200.68,21.89
AGND on IN2 (solid shape): outline of 172 points within 150.39,3.01 191.26,7.42
AGND on SVCC (solid shape): outline of 102 points within 150.39,4.53 200.81,21.89
GND on TOP (solid shape): 24.23,118.34 24.23,115.72 24.18,115.67 21.61,115.67 21.54,115.75 21.54,118.31 21.59,118.36 24.2,118.36
GND on TOP (solid shape): 25.14,78.64 25.14,78.05 25.02,77.93 22.25,77.93 22.21,77.97 22.21,78.69 22.57,79.05 24.74,79.05
GND on TOP (solid shape): 59.99,26.82 59.99,24.71 59.87,24.59 58.44,24.59 58.29,24.74 58.29,26.68 58.84,27.23 59.59,27.23
GND on TOP (solid shape): 113.54,24.74 113.54,24.51 113.33,24.31 110.87,24.31 110.68,24.5 110.68,24.97 110.84,25.14 113.14,25.14
GND on TOP (solid shape): 114.45,84.76 114.45,82.35 113.66,81.56 112.95,81.56 112.55,81.97 112.55,83.51 113.92,84.89 114.32,84.89
GND on TOP (solid shape): 138.07,114.1 138.07,112.32 137.69,111.94 135.79,111.94 135.53,112.19 135.53,114.22 135.79,114.48 137.69,114.48
GND on TOP (solid shape): 152.6,100.81 152.6,96.75 152.42,96.57 149.71,96.57 149.63,96.65 149.63,100.13 150.49,100.99 152.42,100.99
GND on TOP (solid shape): 175.92,74.09 175.92,72.7 175.79,72.57 175.16,72.57 175.03,72.7 175.03,74.09 175.16,74.22 175.79,74.22
GND on TOP (solid shape): 197.13,80.19 197.13,79.55 197,79.43 194.46,79.43 194.33,79.55 194.33,80.06 194.59,80.32 197,80.32
GND on TOP (solid shape): 198.65,64.82 198.65,63.42 198.4,63.17 197.51,63.17 197.38,63.3 197.38,64.82 197.51,64.95 198.52,64.95
GND on TOP (solid shape): 24.13,75.01 24.13,73.43 24.08,73.38 22.45,73.38 22.4,73.43 22.4,75.01 22.45,75.06 24.08,75.06
GND on TOP (solid shape): 63.73,19.56 63.73,16.87 63.73,16.87 61.03,16.87 61.03,16.87 61.03,19.56 61.03,19.56 63.73,19.56
GND on TOP (solid shape): 104.98,40.51 104.98,37.31 104.82,37.16 103.68,37.16 102.36,38.49 102.36,40.66 102.65,40.95 104.54,40.95
GND on TOP (solid shape): 20.22,107.65 20.22,105.97 20.12,105.87 16.23,105.87 16.06,106.04 16.06,107.76 16.2,107.9 19.97,107.9
GND on TOP (solid shape): 54.16,52.36 54.16,49.29 53.72,48.85 44.67,48.85 44.2,49.32 44.2,52.41 44.53,52.74 53.78,52.74
GND on TOP (solid shape): 67.14,42.21 67.14,39.7 67.14,39.7 66.26,39.7 66.25,39.7 66.25,42.19 66.33,42.27 66.83,42.27 66.83,42.27 67.09,42.27
GND on TOP (solid shape): 90.83,89.33 90.83,88.82 90.45,88.44 89.3,88.44 89.18,88.57 89.18,89.46 89.3,89.59 90.57,89.59
GND on TOP (solid shape): 143.53,114.33 143.53,112.07 143.41,111.94 141.12,111.94 140.99,112.07 140.99,114.33 141.04,114.38 143.48,114.38
GND on TOP (solid shape): 145.77,100.13 145.77,96.67 145.67,96.57 142.62,96.57 142.29,96.9 142.29,100.25 142.62,100.58 145.31,100.58
GND on TOP (solid shape): 197.76,95.3 197.76,91.49 197.51,91.24 194.97,91.24 194.84,91.36 194.84,95.43 194.97,95.56 197.51,95.56
GND on TOP (solid shape): 41.81,52.63 41.81,50.47 42.31,49.97 42.31,49.41 42.11,49.21 39.4,49.21 39.23,49.37 39.23,52.75 39.5,53.02 41.42,53.02
GND on TOP (solid shape): 111.53,38.41 111.53,36.5 112.29,35.74 112.29,34.6 112.16,34.47 110.01,34.47 109.62,34.85 109.62,38.41 109.75,38.53 111.4,38.53
GND on TOP (solid shape): 138.2,95.43 138.2,94.26 138.07,94.13 135.84,94.13 135.43,94.54 135.43,95.4 135.66,95.63 138,95.63
GND on TOP (solid shape): 138.58,100.05 138.58,96.75 138.57,96.71 138.53,96.7 137.41,96.7 136.12,97.99 136.12,100.13 136.14,100.15 138.48,100.15
GND on TOP (solid shape): 141.83,77.39 141.87,77.38 141.88,77.34 141.88,75.62 141.76,75.49 140.87,75.49 140.74,75.62 140.74,77.27 140.87,77.39
GND on TOP (solid shape): 48.54,183.19 48.54,178.23 48.41,178.11 46.78,178.11 46.68,178.2 46.68,179.06 46.38,179.36 46.38,181.01 46.9,181.53 46.9,182.62 47.53,183.25 48.47,183.25
GND on TOP (solid shape): 134.26,22.07 134.26,21.43 134.15,21.32 127.32,21.32 127.2,21.44 127.2,21.95 127.33,22.07 129.74,22.07 129.87,22.2 130.33,22.2 130.43,22.1 131.14,22.1 131.27,22.23 134.11,22.23
GND on TOP (solid shape): 150.39,22.72 150.39,21.48 149.91,20.99 149.91,20.99 149.17,20.26 147.94,20.26 147.72,20.48 147.72,21.51 148.87,22.66 148.89,22.66 149.18,22.95 150.16,22.95
GND on TOP (solid shape): 185.19,29.21 185.19,26.72 185.06,26.59 182.65,26.59 182.4,26.85 182.4,27.61 183.54,28.75 184,28.75 184.64,29.39 185.01,29.39
GND on TOP (solid shape): 63.04,170.16 63.04,169.32 63.18,169.17 64.35,169.17 64.49,169.04 64.49,166.61 64.35,166.47 61.91,166.47 61.79,166.6 61.79,169.05 61.92,169.17 62.6,169.17 62.74,169.31 62.74,170.15 62.8,170.21 62.99,170.21
GND on TOP (solid shape): 182.14,23.67 182.14,21.59 182.14,19.43 182.55,19.02 182.55,18.62 182.45,18.52 181.68,18.52 181.63,18.57 181.63,19.23 181.24,19.62 181.24,22.69 181.13,22.8 181.13,23.67 181.22,23.77 182.05,23.77
GND on TOP (solid shape): 182.79,32.07 183.59,32.07 183.79,31.87 183.79,30.39 183.68,30.28 181.25,30.28 181,30.53 181,32.64 181.15,32.79 182.07,32.79
GND on TOP (solid shape): 188.75,25.83 188.75,24.82 188.87,24.69 189.25,24.69 189.38,24.56 189.38,24.05 189.25,23.93 187.91,23.93 187.6,24.23 187.6,25.96 187.73,26.09 188.49,26.09
GND on TOP (solid shape): 181.89,48.57 181.89,38.53 181.86,38.51 180.89,38.51 180.79,38.41 180.49,38.41 180.19,38.71 180.19,41.16 181.01,41.98 181.01,43.68 181.04,43.7 181.01,43.73 181.01,45.06 180.11,45.96 180.11,48.57 180.36,48.82 181.63,48.82
GND on TOP (solid shape): 101.62,55.6 101.62,54.53 101.78,54.38 101.78,53.31 103,52.1 103,50.42 102.69,50.11 101.17,50.11 101.01,50.27 101.01,51.18 100.25,51.94 100.25,53.92 100.1,54.08 97.2,54.08 97.05,54.23 97.05,55.6 97.2,55.75 101.47,55.75
GND on TOP (solid shape): 160.88,11.46 160.98,11.36 161.93,11.36 161.93,11.08 160.98,11.08 160.88,10.98 160.88,9.37 158.19,9.37 158.19,10.98 158.09,11.08 157.14,11.08 157.14,11.36 158.09,11.36 158.19,11.46 158.19,12.07 160.88,12.07
GND on TOP (solid shape): 176.68,16.33 178.24,16.33 178.63,15.94 179.02,15.94 179.1,15.86 179.1,15.49 179.02,15.4 178.34,15.4 178.13,15.19 177.73,15.19 177.49,15.43 176.7,15.43 176.59,15.54 176.59,16.25 176.68,16.33
GND on TOP (solid shape): 179.8,148.27 179.8,145.72 176.38,142.29 175.28,142.29 175.16,142.16 175.16,139.88 174.78,139.5 172.74,139.5 172.62,139.62 172.62,144.32 171.73,145.21 171.73,148.11 172.26,148.64 179.44,148.64
GND on TOP (solid shape): 45.74,172.77 45.74,170.15 45.73,170.12 45.69,170.1 44.45,170.1 44.3,170.26 44.3,172.76 44.56,173.02 45.42,173.02 45.49,173.03
GND on TOP (solid shape): 162.84,75.34 162.84,74.7 163.09,74.45 163.75,74.45 164.54,75.24 165.05,75.24 165.12,75.16 165.12,72.73 164.97,72.57 163.37,72.57 161.29,74.65 161.29,75.36 161.47,75.54 162.63,75.54
GND on TOP (solid shape): 184.65,17.29 184.68,17.3 184.72,17.29 184.81,17.2 184.81,16.18 184.94,16.05 187.09,16.05 187.22,15.93 187.22,10.59 187.09,10.47 181.99,10.47 181.63,10.82 181.63,15.93 181.76,16.05 184.43,16.05 184.55,16.18 184.55,17.2
GND on TOP (solid shape): 141.22,95.2 141.22,92.86 141.32,92.76 142.26,92.76 143.03,93.52 149.88,93.52 150.52,92.89 152.55,92.89 152.68,92.76 152.68,92.63 152.19,92.14 147.8,92.14 147.36,91.71 143.17,91.71 142.58,91.11 140.64,91.11 140.16,91.59 140.16,95.33 140.26,95.43 140.99,95.43
GND on TOP (solid shape): 199.02,59.87 199.03,59.86 199.15,59.84 199.26,59.86 199.29,59.86 199.31,59.84 199.41,59.74 199.41,59.49 199.16,59.23 197.51,59.23 196.75,58.47 196.11,58.47 195.98,58.6 195.98,59.61 196.24,59.87 196.95,59.87
GND on TOP (solid shape): 94.77,43.49 94.77,42.65 94.46,42.34 94.16,42.34 93.7,41.88 93.7,39.3 93.54,39.14 92.94,39.14 92.78,38.99 92.78,37.5 92.67,37.38 92.06,37.38 91.63,37.81 90.79,37.81 90.59,38.01 90.59,39.82 91.41,40.64 91.41,41.88 91.08,42.22 91.08,43.49 91.21,43.61 94.64,43.61
GND on TOP (solid shape): 119.07,185.58 119.07,181.94 118.64,181.51 117.65,181.51 117.32,181.84 117.32,182.58 117.7,182.96 117.7,183.79 117.02,184.47 117.02,184.87 116.62,185.27 115.6,185.27 114.97,185.9 114.97,186.68 115.26,186.97 116.24,187.96 116.7,187.96
GND on TOP (solid shape): 18.62,117.98 18.62,117.93 18.79,117.75 18.79,117.25 18.72,117.17 16.58,117.17 16.57,117.18 16.33,116.94 16.33,116.18 16.61,115.9 16.63,115.9 16.66,115.87 17.8,115.87 17.8,115.87 17.91,115.77 17.91,115.3 17.74,115.14 15.95,115.14 15.87,115.22 15.85,115.22 15.72,115.34 15.72,117.88 15.95,118.11 18.49,118.11
GND on TOP (solid shape): 191.87,68.28 191.87,65.84 192,65.71 192.17,65.71 192.19,65.72 192.7,65.72 192.71,65.71 192.94,65.71 193.09,65.56 193.09,65.15 193.32,64.92 193.85,64.92 193.9,64.87 193.91,64.87 193.91,63.56 193.89,63.54 191.81,63.54 189.38,65.96 189.38,67.11 190.6,68.33 191.82,68.33
GND on TOP (solid shape): 106.7,186.34 106.7,183.95 109.17,181.48 109.17,181 109.07,180.9 107.96,180.9 107.74,181.11 106.06,181.11 106.06,181.87 105.76,182.17 105.05,182.17 104.67,181.79 103.48,181.79 103.37,181.89 103.37,183.13 103.78,183.54 104.6,183.54 104.8,183.74 104.8,186.39 105,186.59 106.46,186.59
GND on TOP (solid shape): 98.75,40.51 98.75,40.2 98.78,40.18 99.97,40.18 100.01,40.16 100.02,40.13 100.02,40.03 100.01,39.99 99.97,39.97 98.8,39.97 98.75,39.93 98.75,38.84 98.7,38.79 97.03,38.79 96.93,38.88 96.93,40.27 96.83,40.37 95.77,40.37 95.74,40.41 95.74,40.56 95.75,40.58 98.69,40.58
GND on TOP (solid shape): 174.39,127.05 174.39,126.67 174.65,126.42 175.92,126.42 176.93,125.4 177.77,125.4 177.95,125.22 177.95,124.51 177.85,124.41 177.34,124.41 177.11,124.64 176.81,124.64 176.05,125.4 174.01,125.4 173.51,125.91 171.93,125.91 171.89,125.92 171.88,125.96 171.88,126.9 172.03,127.05 173.63,127.05 173.76,127.18 174.27,127.18
GND on TOP (solid shape): 144.84,22.54 144.86,22.53 144.96,22.45 145.06,22.43 145.18,22.43 145.2,22.42 145.21,22.41 145.33,22.28 145.57,22.04 145.57,21.64 145.44,21.51 145.06,21.51 144.8,21.26 144.8,20.32 144.6,20.12 143.47,20.12 143.28,20.31 143.28,21.61 144.2,22.54
GND on TOP (solid shape): 175.66,36.12 175.66,35.1 175.54,34.98 174.01,34.98 173.89,35.1 173.89,35.33 173.89,35.35 173.91,35.37 174.02,35.53 174.04,35.72 174.05,35.78 174.26,35.98 174.29,36 174.33,36.03 174.37,36.06 174.68,36.37 175.41,36.37
GND on TOP (solid shape): 163.73,121.32 163.73,117.7 163.71,117.67 163.68,117.65 163.19,117.65 162.91,117.37 162.91,116.89 163.73,116.08 163.73,115.47 164.03,115.16 164.03,114.53 163.73,114.22 163.73,111.91 163.71,111.88 163.68,111.86 163.38,111.86 163.35,111.88 163.33,111.91 163.33,115.48 161.52,117.29 161.52,117.3 161.03,117.78 161.03,121.44 161.36,121.77 163.28,121.77
GND on TOP (solid shape): 179.38,70.14 179.39,70.13 179.47,70.06 179.58,70.03 179.86,70.03 179.97,70.06 180.07,70.15 180.09,70.16 180.14,70.16 180.16,70.14 180.17,70.13 180.25,70.06 180.36,70.03 180.61,70.03 180.87,69.77 180.87,68.38 180.74,68.25 178.84,68.25 178.71,68.38 178.71,69.6 179.27,70.16 179.36,70.16
GND on TOP (solid shape): 25.43,112.26 25.44,112.25 25.52,112.13 25.65,112.09 25.95,112.09 26.03,112.06 26.06,111.99 26.06,110.01 26.04,109.97 26.01,109.96 25.42,109.96 25.07,110.31 25.07,110.87 24.71,111.23 24.36,111.23 24.28,111.3 24.28,112.83 24.3,112.86 24.33,112.88 24.82,112.88
GND on TOP (solid shape): 104.86,99.38 104.86,96.09 103.68,96.09 103.27,95.68 103.27,94.64 103.2,94.57 103.2,94.13 103.1,93.81 103.26,93.52 103.27,93.5 103.27,93.48 103.27,92.25 103.15,92.13 100.1,92.13 99.08,91.11 98.45,91.11 98.07,91.49 98.07,95.95 101.74,99.62 103.66,99.62 103.68,99.62 104.62,99.62
GND on TOP (solid shape): 131.95,114.59 131.95,112.07 131.75,111.86 131.16,111.86 130.94,112.09 130.94,112.7 130.76,112.88 130.72,112.88 130.71,112.89 130.65,112.92 130.58,112.93 130.28,112.93 130.19,112.91 130.11,112.86 130.08,112.82 130.06,112.76 130.02,112.73 130.02,110.57 128.53,109.08 128.22,109.08 127.44,109.86 127.44,112.25 129.37,114.19 129.9,114.19 130.65,114.94 131.61,114.94
GND on TOP (solid shape): 74.88,86.61 74.88,86.13 74.64,85.89 72.12,85.89 71.98,85.75 71.6,85.75 71.57,85.76 71.55,85.79 71.29,86.1 70.91,86.01 70.79,85.89 70.78,85.88 70.76,85.88 70.29,85.88 70.22,85.91 70.19,85.99 70.19,86.04 70.19,86.49 70.36,86.66 70.37,86.67 70.39,86.67 71.61,86.67 71.78,86.84 74.65,86.84
GND on TOP (solid shape): 118.77,38.02 118.77,34.85 118.39,34.47 116.1,34.47 115.97,34.6 115.15,34.6 115.06,34.65 115.07,34.76 115.06,35.66 114.2,35.93 114.11,35.94 114.07,36.02 114.07,36.5 113.12,37.45 113.12,38.49 113.42,38.79 118.01,38.79
GND on TOP (solid shape): 186.04,59.43 186.04,58.31 186.08,58.27 186.69,58.27 186.73,58.31 186.73,58.85 187.04,58.85 187.04,56.86 187.25,56.65 187.26,56.62 187.31,56.58 187.35,56.54 187.4,56.51 187.46,56.48 187.52,56.47 187.58,56.46 187.71,56.46 187.78,56.39 187.78,56.01 187.65,55.88 187.31,55.88 187.23,55.96 187.23,56.42 187.11,56.54 184.96,56.54 184.71,56.29 183.79,56.29 183.74,56.34 183.74,57 183.8,57.06 185.39,57.06 185.39,57.25 184.93,57.25 184.93,57.06 183.8,57.06 183.87,57.12 184.61,57.12 185.01,57.53 185.49,57.53 185.57,57.61 185.57,58.14 185.47,58.24 184.73,58.24 184.57,58.4 185.73,58.4 185.73,58.86 185.54,58.86 185.54,58.4 184.57,58.4 184.45,58.52 183.64,58.52 183.56,58.6 183.56,59.19 183.73,59.35 184.39,59.35 184.63,59.58 185.89,59.58
GND on TOP (solid shape): 196.65,49.48 196.65,45.87 196.28,45.49 195.87,45.09 194.97,45.09 194.73,44.84 194.73,42.96 194.43,42.65 193.63,42.65 193.29,42.32 193.29,41.79 192.83,41.33 191.95,40.44 191.95,40.36 191.87,40.28 191.87,39.93 191.64,39.7 191.01,39.7 190.47,39.17 189.05,39.17 188.94,39.06 188.94,37.44 188.93,37.4 188.89,37.39 188.73,37.39 188.69,37.43 188.69,39 188.6,39.09 186.47,39.09 186.34,38.97 186.34,37.4 186.33,37.39 186.14,37.39 186.1,37.4 186.09,37.44 186.09,38.92 185.69,38.92 185.69,37.44 185.68,37.4 185.64,37.39 185.49,37.39 185.46,37.4 185.44,37.44 185.44,39.42 184.94,39.93 184.94,42.34 185.34,42.75 186.54,42.75 186.74,42.95 186.74,44.54 186.75,44.56 186.78,44.59 186.81,44.59 186.83,44.58 186.92,44.58 186.99,44.5 186.99,42.82 187.09,42.72 193.01,42.72 193.45,43.16 193.45,44.61 194.3,45.45 194.3,48.53 194.49,48.72 195.48,48.72 195.6,48.84 195.6,50.04 195.63,50.06 196.07,50.06
GND on TOP (solid shape): 95.21,4.42 98.08,4.42 100,6.35 106.71,6.35 108.18,4.88 137.37,4.88 138.26,3.99 149.88,3.99 149.88,3.01 104.8,3.01 104.77,3.01 104.03,2.8 103.49,2.26 103.34,1.89 103.29,1.5 103.29,0.99 103.14,0.65 102.8,0.51 99.8,0.51 99.45,0.65 99.31,1 99.31,1.5 98.88,2.56 97.83,3.01 97.8,3.01 77.05,3.01 77.05,4.02 81.53,4.02 85.88,8.37 91.27,8.37
GND on TOP (solid shape): 14.68,55.63 15.41,55.63 17.68,53.37 17.68,52.96 17.6,52.88 17.17,52.88 16.91,52.63 16.91,48.95 16.71,48.74 13.48,48.74 13.2,49.02 13.2,50.45 12.95,51.07 12.35,51.36 12.02,51.23 11.76,50.99 11.75,50.98 11.71,50.96 3.8,50.96 3.45,51.1 3.31,51.45 3.31,52.95 3.45,53.29 3.79,53.44 11.25,53.44 11.54,53.44 12.56,53.08 13.2,53.95 13.2,55.64 14.68,55.64
GND on TOP (solid shape): 120.42,99.37 120.42,97.97 119.97,97.52 119.87,97.49 119.8,97.57 119.57,97.84 119.22,97.8 117.62,97.8 117.6,97.82 117.59,97.84 117.05,98.05 116.93,97.48 116.96,97.41 117.01,97.35 117.19,97.17 118.67,97.17 118.76,97.1 118.74,96.99 117.05,95.3 115.4,95.3 115.37,95.32 115.35,95.35 115.35,95.63 114.91,96.08 114.46,95.63 114.46,95.48 111.57,95.48 111.35,95.84 110.94,95.77 110.83,95.76 110.77,95.85 110.77,99.24 111.02,99.49 120.29,99.49
GND on TOP (solid shape): outline of 113 points within 0.51,65.98 15.49,159.9
GND on TOP (solid shape): outline of 760 points within 3.31,3.01 74.31,39.29
GND on TOP (solid shape): outline of 1157 points within 134.34,26.09 148.55,34.19
GND on TOP (solid shape): outline of 1097 points within 167.17,27.61 175.69,51.23
GND on TOP (solid shape): outline of 1378 points within 7.9,5.96 205.29,192.29
GND on TOP (solid shape): outline of 2666 points within 152.84,24.44 167.62,55.2
GND on BOTTOM (solid shape): 24.23,118.34 24.23,115.72 24.18,115.67 21.61,115.67 21.54,115.75 21.54,118.31 21.59,118.36 24.2,118.36
GND on BOTTOM (solid shape): 55.14,57.59 55.14,56.24 54.9,56 53.78,56 52.84,56.94 52.84,57.81 53.03,58.01 54.72,58.01
GND on BOTTOM (solid shape): 98.73,40.36 98.73,38.99 98.58,38.84 97.39,38.84 97.05,39.17 97.05,40.36 97.2,40.51 98.58,40.51
GND on BOTTOM (solid shape): 141.88,77.39 141.88,75.49 141.76,75.36 140.1,75.36 139.98,75.49 139.98,77.39 140.1,77.52 141.76,77.52
GND on BOTTOM (solid shape): 147.09,77.78 147.09,75.11 146.84,74.85 145.06,74.85 144.8,75.11 144.8,77.78 144.93,77.9 146.96,77.9
GND on BOTTOM (solid shape): 153.39,117.68 153.39,114.05 153.03,113.69 151.28,113.69 151.07,113.91 151.07,117.49 151.44,117.86 153.21,117.86
GND on BOTTOM (solid shape): 175.64,153.14 175.64,152.3 174.5,152.3 173.51,153.3 173.51,154.02 173.66,154.17 174.62,154.17
GND on BOTTOM (solid shape): 175.92,74.09 175.92,72.7 175.79,72.57 175.16,72.57 175.03,72.7 175.03,74.09 175.16,74.22 175.79,74.22
GND on BOTTOM (solid shape): 180.62,125.4 180.62,122.86 180.36,122.61 177.82,122.61 177.57,122.86 177.57,125.4 177.82,125.65 180.36,125.65
GND on BOTTOM (solid shape): 24.13,74.83 24.13,73.43 24.08,73.38 22.47,73.38 22.41,73.42 22.4,73.43 22.4,74.88 22.48,74.96 24,74.96
GND on BOTTOM (solid shape): 63.73,19.56 63.73,16.87 63.73,16.87 61.03,16.87 61.03,16.87 61.03,19.56 61.03,19.56 63.73,19.56
GND on BOTTOM (solid shape): 76.93,83.49 76.93,80.16 76.73,79.96 75.41,79.96 74.73,79.27 74.45,79.27 73.3,80.42 73.3,83.06 74.55,84.3 76.12,84.3
GND on BOTTOM (solid shape): 173,162.74 173,161.85 172.24,161.09 172.24,159.56 172.11,159.44 170.03,159.44 168.93,160.53 168.93,162.61 169.18,162.86 172.88,162.86
GND on BOTTOM (solid shape): 105.13,39.9 105.13,37.62 103.76,36.25 101.93,36.25 101.47,36.7 101.47,39.9 101.93,40.36 104.67,40.36
GND on BOTTOM (solid shape): 114.7,19.61 114.7,16.18 114.32,15.8 109.12,15.8 107.42,17.5 107.42,18.64 109.17,20.4 113.92,20.4
GND on BOTTOM (solid shape): 91.26,59.51 91.26,55.4 91.25,55.36 91.21,55.35 89,55.35 88.92,55.42 88.92,59.69 89.15,59.92 90.85,59.92
GND on BOTTOM (solid shape): 168.93,132.89 168.93,131.12 168.81,130.99 163.98,130.99 163.47,131.5 163.47,132.64 164.08,133.25 168.58,133.25
GND on BOTTOM (solid shape): 191.31,30 191.31,27.69 191.11,27.48 188.87,27.48 188.75,27.61 188.75,30.02 188.88,30.16 191.15,30.16
GND on BOTTOM (solid shape): 92.12,77.39 92.12,74.6 92.4,74.32 92.4,73.46 92.05,73.1 89.81,73.1 88.59,74.32 88.59,77.57 88.82,77.8 91.72,77.8
GND on BOTTOM (solid shape): 186.59,14.76 187.04,14.76 187.17,14.63 187.17,13.23 187.09,13.16 187.09,10.85 186.84,10.59 182.37,10.59 182.27,10.69 182.27,13.5 182.67,13.89 182.68,13.89 184.07,15.29 186.05,15.29
GND on BOTTOM (solid shape): 188.34,112.68 188.34,111.79 187.36,110.81 186.95,110.81 186.84,110.92 186.84,111.3 187.21,111.67 187.21,113.19 187.22,113.23 187.26,113.25 187.77,113.25
GND on BOTTOM (solid shape): 188.34,59.29 188.34,56.12 188.1,55.88 188.09,55.88 187.64,55.43 187.64,55.24 187.46,55.07 184.55,55.07 184.28,55.35 184.28,59.25 184.68,59.66 187.97,59.66
GND on BOTTOM (solid shape): 196.88,32.65 196.88,32.06 196.87,32.06 196.87,29.39 196.49,29.01 194.36,29.01 194.35,29.02 191.67,29.02 191.48,29.2 191.48,31.11 191.54,31.17 193.44,31.17 195.14,32.86 196.67,32.86
GND on BOTTOM (solid shape): 137.06,77.52 137.06,75.36 136.93,75.24 135.91,75.24 135.41,75.74 135.41,77.01 135.73,77.34 135.75,77.34 135.94,77.39 136.1,77.51 136.24,77.65 136.93,77.65
GND on BOTTOM (solid shape): 185.32,80.94 185.32,80.44 186.21,79.55 190.65,79.55 190.82,79.39 190.82,78.5 190.73,78.41 185.42,78.41 184.91,77.9 183.89,77.9 183.6,78.19 182.36,78.19 182.07,78.49 182.07,79.48 182.78,80.19 182.78,81.2 183.03,81.46 184.8,81.46
GND on BOTTOM (solid shape): 93.7,38.9 93.73,38.88 93.75,38.85 93.75,38.02 93.55,37.82 92.76,37.82 92.74,37.78 92.71,37.77 90.32,37.77 90.07,38.02 90.07,38.79 90.18,38.9
GND on BOTTOM (solid shape): 26.34,109.68 26.37,109.66 26.39,109.63 26.39,105.28 26.37,105.25 26.34,105.23 23.93,105.23 22.71,106.46 22.71,109.63 22.72,109.66 22.76,109.68
GND on BOTTOM (solid shape): 125.14,180.49 126.19,180.49 126.52,180.16 126.52,174.42 126.26,174.17 116.76,174.17 116.51,174.42 116.51,177.55 116.66,177.7 121.44,177.7 121.69,177.95 121.69,178.92 121.23,179.38 121.23,180.24 121.61,180.62 123.26,180.62 123.87,181.23 124.41,181.23
GND on BOTTOM (solid shape): 168.86,147.07 178.64,147.07 178.89,146.81 178.89,137.74 178.66,137.52 163.52,137.52 154.96,128.96 154.96,126.42 154.46,125.91 142.77,125.91 140.74,127.94 132.36,127.94 131.6,128.7 128.55,128.7 126.52,130.73 117.12,130.73 105.69,142.16 105.69,157.4 106.2,157.91 158.01,157.91
GND on BOTTOM (solid shape): 61.11,59.49 61.11,58.98 61.36,58.73 61.87,58.73 62.13,58.47 62.13,55.55 61.99,55.41 59.47,55.41 59.33,55.55 59.33,58.54 59.43,58.8 59.33,59.06 59.33,59.74 59.59,60 60.6,60
GND on BOTTOM (solid shape): 125.14,111.26 125.14,108.41 123.98,107.24 119.53,107.24 118.64,108.13 118.64,112.6 118.06,113.18 114.93,113.18 114.92,113.2 114.39,113.2 114.25,113.34 112.9,113.34 112.49,112.93 112.49,111.89 112.37,111.76 111.51,111.76 111.48,111.77 111.46,111.81 111.46,113.12 112.71,114.36 122.05,114.36
GND on BOTTOM (solid shape): 103.89,98.12 104.88,98.12 104.88,94.85 104.82,94.79 103.53,94.79 103.27,94.54 103.27,94.23 103.27,94.21 103.26,94.19 103.1,93.85 103.26,93.52 103.27,93.5 103.27,93.48 103.27,92.25 103.15,92.13 100.1,92.13 99.21,91.24 98.7,91.24 98.19,91.75 98.19,96.36 101.2,99.37 102.64,99.37
GND on BOTTOM (solid shape): 158.27,77.14 158.57,77.14 158.6,77.14 159.25,77.14 159.28,77.14 159.58,77.14 159.65,77.12 159.66,77.09 159.66,75.29 159.65,75.25 159.61,75.24 158.55,75.24 158.51,75.25 158.5,75.29 158.5,75.82 158.01,76.3 158.01,77.01 158.14,77.14
GND on BOTTOM (solid shape): 48.66,57.96 48.66,55.93 48.03,55.3 48.03,53.78 47.9,53.65 47.34,53.65 46.63,52.94 46.63,51.74 47.01,51.36 50.65,51.36 50.7,51.31 50.7,51.31 51.1,50.9 53.8,50.9 53.87,50.83 53.87,48.9 53.82,48.84 53.61,48.84 53.56,48.9 53.56,50.27 51.86,50.27 51.86,48.91 51.72,48.77 47.83,48.77 46.63,49.96 45.74,49.96 45.62,50.09 44.73,50.09 44.47,50.34 44.47,56.62 44.83,56.97 46.79,56.97 47.9,58.09 48.54,58.09
GND on BOTTOM (solid shape): 191.37,68.32 191.8,68.32 191.8,68.07 191.37,68.07 191.37,67.82 191.81,67.82 191.81,67.57 191.37,67.57 191.37,67.32 191.81,67.32 191.81,67.07 191.37,67.07 191.37,66.82 191.82,66.82 191.82,65.84 191.95,65.71 192.95,65.71 193.08,65.58 193.08,64.95 193.14,64.89 193.14,63.78 191.34,61.98 190.68,61.98 190.35,61.65 189.56,61.65 187.93,60.02 184.73,60.02 184.61,60.15 184.61,62.87 184.71,62.97 185.55,62.97 186.87,64.29 186.87,65.53 187.33,66 188.35,66 188.72,66.37 188.72,66.85 188.92,67.05 189.63,67.05 190.9,68.33 191.37,68.33
GND on BOTTOM (solid shape): 112.82,26.99 112.82,24.94 112.86,24.9 114.24,24.9 114.28,24.94 114.28,27.02 114.31,27.04 114.59,27.04 114.62,27.01 114.62,24.98 114.68,24.92 116.02,24.92 116.08,24.98 116.08,27.01 116.11,27.04 116.38,27.04 116.42,27 116.42,24.99 116.48,24.92 117.84,24.92 117.89,24.96 117.89,27.01 117.92,27.04 118.17,27.04 118.17,27.04 118.22,26.99 118.22,24.94 118.24,24.92 119.61,24.92 119.68,24.99 119.68,27.02 119.7,27.04 120.02,27.04 120.02,25.03 120.28,25.03 120.28,27.04 120.59,27.04 120.62,27.01 120.62,24.59 119.98,23.94 117.53,23.94 117.52,23.93 113.38,23.93 112.49,24.82 112.49,27.01 112.53,27.04 112.77,27.04
GND on BOTTOM (solid shape): 32.71,58.7 32.71,55.75 32.41,55.45 32.41,53.42 32.4,53.38 32.36,53.37 32.31,53.37 32.27,53.38 32.26,53.42 32.26,53.52 31.29,53.52 31.29,52.45 32.3,52.45 32.4,52.35 32.41,52.34 32.41,52.32 32.41,51.88 32.4,51.84 32.36,51.83 32.31,51.83 32.26,51.89 32.26,52.05 31.29,52.05 31.29,50.98 31.91,50.98 32.48,50.41 32.52,50.37 32.57,50.34 32.59,50.32 32.59,50.3 32.59,47.96 31.9,47.27 30.8,47.27 30.63,47.44 29.22,47.44 29.2,47.44 29.18,47.45 28.42,48.21 28.42,58.04 29.59,59.21 32.21,59.21
GND on BOTTOM (solid shape): 43.84,162.99 43.84,153.85 40.41,150.42 34.95,150.42 34.06,151.31 34.06,155.51 42.49,155.51 42.5,155.46 42.51,155.4 42.53,155.35 42.56,155.3 42.6,155.26 42.64,155.22 42.69,155.19 42.74,155.17 42.79,155.15 42.85,155.14 42.9,155.14 42.96,155.15 43.01,155.17 43.06,155.19 43.11,155.22 43.15,155.26 43.18,155.3 43.21,155.35 43.24,155.4 43.25,155.46 43.26,155.51 43.25,155.57 43.24,155.62 43.23,155.67 43.2,155.72 43.17,155.77 43.13,155.81 43.08,155.84 43.04,155.87 42.98,155.89 42.93,155.9 42.87,155.91 42.82,155.9 42.76,155.89 42.71,155.87 42.66,155.84 42.62,155.81 42.58,155.77 42.55,155.72 42.52,155.67 42.5,155.62 42.49,155.57 42.49,155.51 34.06,155.51 34.06,162.23 35.2,163.37 43.46,163.37
GND on BOTTOM (solid shape): 102.86,33.59 102.86,33.35 102.84,33.31 102.81,33.3 101.3,33.3 101.3,33.1 102.81,33.1 102.84,33.09 102.86,33.05 102.86,32.85 102.84,32.81 102.81,32.8 101.3,32.8 101.3,32.6 102.81,32.6 102.84,32.59 102.86,32.55 102.86,32.35 102.84,32.31 102.81,32.3 101.3,32.3 101.3,32.1 102.81,32.1 102.84,32.09 102.86,32.05 102.86,31.85 102.84,31.81 102.81,31.8 100.19,31.8 99.67,32.31 99.67,33.39 100.02,33.74 102.71,33.74
GND on BOTTOM (solid shape): 194.84,76.28 194.84,71.86 194.79,71.81 194.11,71.81 194.09,71.82 193.3,71.82 192.94,72.19 192.94,74.22 192.97,74.3 193.05,74.32 193.4,75.11 192.64,74.7 192.64,74.68 192.54,74.57 191.97,74.57 191.77,74.37 191.49,74.37 191.34,74.52 191.34,76.35 191.57,76.58 194.54,76.58
GND on BOTTOM (solid shape): 40.92,57.96 40.92,56.06 41.29,55.69 41.95,55.69 42.19,55.45 42.19,49 42.18,48.97 42.17,48.95 42.14,48.95 40.28,48.95 40.26,48.97 40.26,49.17 40.28,49.2 41.55,49.2 41.68,49.33 41.68,50.72 41.55,50.85 39.39,50.85 39.14,51.11 39.14,51.61 38.63,52.12 38.63,52.43 38.17,52.88 35.2,52.88 35.08,53.01 35.08,53.77 38.12,53.77 38.13,53.72 38.14,53.66 38.16,53.61 38.19,53.56 38.22,53.52 38.26,53.48 38.31,53.45 38.36,53.42 38.41,53.4 38.46,53.39 38.52,53.39 38.57,53.4 38.63,53.41 38.68,53.43 38.73,53.46 38.77,53.5 38.81,53.54 38.84,53.58 38.86,53.64 38.88,53.69 38.89,53.74 38.89,53.8 38.88,53.86 38.86,53.91 38.84,53.96 38.81,54.01 38.77,54.05 38.73,54.08 38.68,54.11 38.63,54.13 38.57,54.15 38.52,54.15 38.46,54.15 38.41,54.14 38.36,54.12 38.31,54.1 38.26,54.07 38.22,54.03 38.19,53.98 38.16,53.93 38.14,53.88 38.13,53.83 38.12,53.77 35.08,53.77 35.08,57.33 35.36,57.61 40.07,57.61 40.49,58.03 40.85,58.03
GND on BOTTOM (solid shape): 178.76,15.82 178.15,15.2 176.95,15.2 176.77,15.38 176.24,15.44 176.17,14.91 176.17,14.86 176.13,14.83 176.02,14.83 175.84,15.01 175.84,15.04 175.61,15.04 175.03,15.61 174.69,15.61 174.55,15.75 174.41,15.75 174.14,16.02 174.17,16.05 173.87,16.66 173.54,16.07 173.55,16.06 173.55,15.99 173.47,15.99 172.36,17.1 172.36,18.49 174.32,20.45 178.76,20.45
GND on BOTTOM (solid shape): outline of 98 points within 114.59,46.69 133.51,51.64
GND on BOTTOM (solid shape): 158.47,121.31 158.5,121.23 158.46,121.16 158.66,120.48 158.99,121.1 158.98,121.11 158.98,121.13 159,121.17 159.03,121.18 159.09,121.18 159.18,121.09 160.27,121.09 160.36,121.18 161.16,121.18 161.42,121.44 162.99,121.44 163.05,121.38 163.05,121.35 163.12,121.12 163.31,120.97 163.33,120.97 163.35,120.94 163.35,120.45 162.91,120.02 161.03,120.02 160.25,119.23 157.12,119.23 157.01,119.34 157.01,120.46 156.77,120.71 156.77,121.12 156.77,121.14 156.79,121.16 156.97,121.51 156.79,121.87 156.77,121.88 156.77,121.91 156.77,122.2 156.84,122.28 157.5,122.28
GND on BOTTOM (solid shape): outline of 104 points within 94.16,49.61 103,59.87
GND on BOTTOM (solid shape): outline of 113 points within 151.57,46.66 173.11,51.38
GND on BOTTOM (solid shape): outline of 135 points within 128.17,116.64 134.64,123.24
GND on BOTTOM (solid shape): outline of 157 points within 81,169.32 89.66,175.3
GND on BOTTOM (solid shape): outline of 160 points within 135.28,112.09 142.41,120.19
GND on BOTTOM (solid shape): outline of 88 points within 101.27,14.6 105.85,29.21
GND on BOTTOM (solid shape): outline of 211 points within 152.39,33.29 173.11,40.38
GND on BOTTOM (solid shape): outline of 223 points within 110.01,33.25 133.86,40.39
GND on BOTTOM (solid shape): 36.3,188.99 36.55,188.93 36.73,188.75 36.78,188.63 36.79,188.5 36.79,186.7 36.81,186.47 36.86,186.24 36.93,186.06 37.02,185.9 37.03,185.88 37.03,185.6 36.8,185.37 34.26,185.37 33.72,184.83 33.72,179.83 33.25,179.36 32.37,179.36 31.84,179.89 31.84,180.88 31.73,181 30.5,181 30.08,181.42 30.08,182.73 29.76,183.05 28.34,183.05 27.82,182.54 27.82,181.2 27.08,179.42 25.3,178.68 17.3,178.68 17.24,178.68 17.17,178.68 14.33,178.68 12.1,176.45 11.09,176.45 11.09,176.49 11.07,176.65 11.03,176.81 10.67,177.31 10.08,177.5 7.57,177.5 7.48,177.54 7.47,177.64 7.49,178.36 7.01,178.9 6.96,179.01 7.05,179.09 8.3,179.09 9.18,179.37 9.73,180.11 9.79,180.35 9.81,180.6 9.81,184.2 9.81,184.28 9.83,184.35 10.01,184.6 10.3,184.69 15.3,184.69 15.65,184.55 15.79,184.2 15.79,181.2 16.23,180.13 17.3,179.69 25.3,179.69 26.37,180.13 26.81,181.2 26.81,188.5 26.95,188.85 27.3,188.99
GND on BOTTOM (solid shape): outline of 234 points within 36.31,62.43 50.95,63.93
GND on BOTTOM (solid shape): outline of 359 points within 189.89,3.03 205.29,155.95
GND on BOTTOM (solid shape): outline of 427 points within 24.66,35.61 59.41,42.98
GND on BOTTOM (solid shape): outline of 254 points within 69.11,155.9 200.99,192.29
GND on BOTTOM (solid shape): outline of 2602 points within 0.51,0.51 149.88,159.9
GND on SGND (solid shape): outline of 3128 points within 0.51,0.51 205.29,192.29
GND on IN1 (solid shape): 24.23,118.34 24.23,115.72 24.18,115.67 21.61,115.67 21.54,115.75 21.54,118.31 21.59,118.36 24.2,118.36
GND on IN1 (solid shape): 175.92,74.09 175.92,72.7 175.79,72.57 175.16,72.57 175.03,72.7 175.03,74.09 175.16,74.22 175.79,74.22
GND on IN1 (solid shape): 24.13,75.01 24.13,73.43 24.08,73.38 22.45,73.38 22.4,73.43 22.4,75.01 22.45,75.06 24.08,75.06
GND on IN1 (solid shape): 63.73,19.56 63.73,16.87 63.73,16.87 61.03,16.87 61.03,16.87 61.03,19.56 61.03,19.56 63.73,19.56
GND on IN1 (solid shape): 154.07,117.6 154.07,114.83 153.85,114.61 150.87,114.61 150.75,114.73 150.75,117.65 150.76,117.69 150.8,117.7 153.97,117.7
GND on IN1 (solid shape): 26.41,109.68 26.45,109.66 26.47,109.63 26.47,105.49 26.3,105.33 22.76,105.33 22.6,105.49 22.6,109.09 22.71,109.19 23.09,109.19 23.57,109.68
