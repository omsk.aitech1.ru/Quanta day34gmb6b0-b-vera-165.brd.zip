# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CLKREQ_LAN#: length 240.6
  TOP w0.127: v2(175.56,99.59) 176.09,99.59 176.56,99.12 181.85,99.12 182.21,99.12 184,100.91 184,102.79 184.44,103.24 184.44,104.43 184.59,104.58 184.59,107.31 183.65,108.25 183.65,113.57 v2(183.14,114.08) ; v2(36.08,111.34) 34.99,111.34 32.66,113.67 v1(32.66,114.35) 32.66,121.29 30.19,123.76 28.23,123.76 26.44,121.97 R142.1
  IN1 w0.14: v2(183.14,114.08) 182.62,113.56 181,113.56 177.83,116.72 171.15,116.72 168.15,113.73 161.56,113.73 160.23,112.4 143.61,112.4 142.77,111.55 129.64,111.55 125.59,115.6 125.33,115.86 117.23,115.86 115.82,114.45 110.59,114.45 109.04,116 103.04,116 80.09,93.05 56.48,93.05 55.66,92.23 53.31,92.23 52.84,92.69 49.24,92.69 47.95,93.99 39.27,93.99 38.89,94.37 32.45,94.37 32.18,94.64 32.18,107.44 v2(36.08,111.34)
  BOTTOM w0.089: 169.78,98.84 169.44,98.49 168.25,98.49 168.05,98.29 U25.N1
  BOTTOM w0.127: v2(175.56,99.59) 175.51,99.54 175.51,99.08 R519.1 175,99.4 174.46,99.4 173.99,99.87 172.1,99.87 171.88,100.1 171.37,100.1 170.25,98.98 169.93,98.98 169.78,98.84
PCIE_CLKREQ_WLAN#: length 100.1
  TOP w0.127: CN22.7 176.6,162.18 179.98,158.8 179.98,157.66 v2(180.94,156.69) ; v2(188.59,114.06) 186.5,111.97 v1(186.5,111.56) 186.5,110.73 187.53,109.7 187.53,108.59 188.09,108.03 188.09,107.46 188.21,107.33 188.21,106.45 189.02,105.65 189.02,101.34 188.43,100.75 188.43,97.9 187.17,96.65 v2(187.17,96.29)
  IN1 w0.14: v2(180.94,156.69) 181.02,156.69 182.23,155.48 182.23,155 184.05,153.19 184.05,150.39 187.96,146.48 187.96,133.66 191.65,129.97 191.65,115.66 191.23,115.24 189.77,115.24 v2(188.59,114.06) ; v2(169.75,91.75) 170.23,92.23 172.08,92.23 173.36,93.5 173.36,93.51 173.62,93.77 173.63,93.77 176.36,96.5 178.61,96.5 178.87,96.77 186.69,96.77 v2(187.17,96.29)
  BOTTOM w0.127: R530.1 187.73,96.85 v2(187.17,96.29) ; v2(169.75,91.75) 169.13,92.37 167.98,92.37 U25.AD1
PCIE_RCOMP: length 11.8
  TOP w0.305: v2(152.17,106.93) 152.22,106.99 153.96,106.99 155.73,108.75 155.73,110.35 v1(156.46,111.09) 157.38,112 157.38,112.83 157.89,113.34 R150.1
  BOTTOM w0.203: U25.A27 152.55,105.99 152.55,106.55 v2(152.17,106.93)
PCIE_RXN3_WLAN: length 99.9
  IN1 w0.14: v2(163.48,111.23) 163.77,110.93 168.09,110.93 171.95,114.79 176.96,114.79 180.79,110.96 185.2,110.96 185.59,110.57 187.71,110.57 188.39,111.25 192.19,111.25 195.17,114.23 195.17,130.64 191.15,134.66 191.15,150.05 188.14,153.06 188.14,159.34 186.2,161.28 CN22.23
  BOTTOM w0.076: 162.95,109.4 162.98,109.37 162.98,109.28 162.62,108.93 162.62,106.53 161.98,105.88 161.98,105.51 161.73,105.26 161.73,104.57 161.87,104.43 161.87,104.21 161.49,103.83 161.49,103.55 160.91,102.97 160.91,102.05 161.2,101.75 161.35,101.75 U25.G11
  BOTTOM w0.127: v2(163.48,111.23) 162.95,110.7 162.95,109.4
PCIE_RXN4_LAN: length 202.9
  TOP w0.127: v2(25.65,96.76) 25.65,96.63 25.39,96.37 24.52,96.37 24.15,96.74 23.04,96.74 22.11,97.66 21.28,97.66 v1(20.72,98.22) 20.19,97.69 18.46,97.69 17.73,98.42 15.12,101.03 15.12,121.6 16,122.48 19.81,122.48 20.17,122.12 20.17,121.64 20.07,121.55 C225.2
  IN1 w0.14: v2(160.15,102.57) 160.4,102.32 160.59,102.32 160.79,102.53 160.79,103.71 159.71,104.78 153.37,104.78 152.86,104.28 151.93,104.28 151.8,104.41 150.88,105.32 150.33,105.32 148.29,107.36 147.44,107.36 146.31,106.23 141.35,106.23 140.67,106.91 128.04,106.91 126.02,108.93 126.02,111.96 124.39,113.59 121.18,113.59 119.33,111.73 111.2,111.73 109.2,109.74 105.98,109.74 104.68,111.05 101.8,111.05 80.95,90.2 69.09,90.2 68.02,89.13 57.34,89.13 56.94,88.74 37.45,88.74 36.63,89.55 32.43,89.55 31.54,90.44 28.99,90.44 26.94,92.49 24.65,94.78 24.65,95.92 25.06,96.33 25.35,96.33 25.65,96.64 v2(25.65,96.76)
  BOTTOM w0.076: U25.F13 160.59,102.29 160.59,102.5 160.52,102.57 v2(160.15,102.57)
PCIE_RXN4_LAN_L: length 3.8
  TOP w0.127: C225.1 19.86,120.51 19.86,119.74 19.76,119.63 19.76,118.31 19.97,118.1 20.17,118.1 20.26,118.02 U8.18
PCIE_RXN5_CARD: length 157.1
  TOP w0.076: 159.87,103.3 159.86,103.3 159.82,103.26 159.79,103.26 159.68,103.15 159.68,103.11 159.57,103.01 159.57,100.37 159.22,100.02 159.22,99.96
  TOP w0.127: C541.1 68.49,20.88 68.63,20.88 69.11,21.36 69.11,23.52 74.8,29.21 79.39,29.21 88.03,37.85 88.03,51.29 86.41,52.92 86.41,54.25 88.19,56.03 88.19,61.9 v2(87.9,62.19) ; 159.87,103.3 160.73,103.3 161.35,103.91 162.3,103.91 162.68,103.54 162.81,103.4 162.81,102.41 162.81,102.22 162.59,101.99 162.03,101.99 v2(161.99,101.95) ; 159.22,99.96 159.22,98.91 158.94,98.63 158.49,98.63 v2(158.29,98.83)
  IN1 w0.14: v2(87.9,62.19) 88.16,62.45 88.16,63.17 90.31,65.31 90.31,67.03 95.99,72.71 102.3,72.71 111.14,81.54 111.14,84.71 111.82,85.4 111.82,86.36 119.77,94.31 121.03,94.31 121.67,94.95 123.37,94.95 125.78,97.35 133.57,97.35 134.83,96.09 144.16,96.09 144.76,95.49 150.33,95.49 151.45,96.61 154.37,96.61 156.11,98.35 157.1,98.35 157.4,98.65 158.11,98.65 v2(158.29,98.83)
  BOTTOM w0.076: v2(161.99,101.95) 162.28,102.25 U25.F10
PCIE_RXN5_CARD_C: length 4.9
  TOP w0.127: C541.2 67.32,21.02 67.18,20.88 66.72,20.88 v1(66.23,21.37) 66.23,20.99 66.09,20.85 65.76,20.85 65.45,20.55 65.45,19.65 65.33,19.53 65.23,19.53 65.15,19.61 U19.8
PCIE_RXP3_WLAN: length 99.9
  IN1 w0.14: CN22.25 187,162.57 186.47,162.04 186.47,161.39 188.4,159.45 188.4,153.17 191.41,150.16 191.41,134.77 195.44,130.75 195.44,114.12 192.31,110.99 188.5,110.99 187.82,110.31 185.48,110.31 185.09,110.69 180.68,110.69 176.85,114.53 172.06,114.53 168.2,110.67 163.58,110.67 v2(163.45,110.54)
  BOTTOM w0.076: 163.18,109.4 163.15,109.37 163.15,109.21 162.8,108.85 162.8,106.45 162.16,105.81 162.16,105.44 161.91,105.19 161.91,104.65 162.05,104.5 162.05,104.14 161.67,103.76 161.67,103.48 161.09,102.89 161.09,102.12 161.28,101.93 161.54,101.93 161.59,101.98 161.59,102.12 161.61,102.14 U25.F11
  BOTTOM w0.127: v2(163.45,110.54) 163.32,110.54 163.18,110.4 163.18,109.4
PCIE_RXP4_LAN: length 202.9
  TOP w0.127: v2(25.65,96) 25.51,96.14 24.43,96.14 24.06,96.51 22.94,96.51 22.02,97.43 21.21,97.43 v1(20.72,96.95) 20.22,97.46 18.37,97.46 17.96,97.87 17.39,98.44 14.9,100.93 14.9,121.7 15.91,122.71 19.9,122.71 20.39,122.22 20.39,121.78 C226.2
  IN1 w0.14: v2(25.65,96) 25.59,96.06 25.17,96.06 24.92,95.81 24.92,94.89 27.13,92.68 29.1,90.7 31.66,90.7 32.54,89.82 36.74,89.82 37.56,89 56.83,89 57.23,89.4 67.91,89.4 68.98,90.47 80.84,90.47 101.69,111.32 104.79,111.32 106.09,110.01 109.09,110.01 111.09,112 119.22,112 121.07,113.86 124.5,113.86 126.29,112.07 126.29,109.04 128.15,107.18 140.78,107.18 141.46,106.5 146.2,106.5 147.33,107.63 148.4,107.63 150.44,105.59 150.99,105.59 151.99,104.6 152.04,104.55 152.75,104.55 153.26,105.05 159.83,105.05 161.06,103.82 161.06,102.42 160.7,102.06 160.29,102.06 v2(160.15,101.92)
  BOTTOM w0.076: v2(160.15,101.92) 160.48,101.6 U25.G13
PCIE_RXP4_LAN_L: length 3.7
  TOP w0.127: C226.1 20.21,120.77 20.09,120.65 20.09,119.64 19.99,119.54 19.99,118.41 20.06,118.33 20.19,118.33 20.27,118.42 U8.17
PCIE_RXP5_CARD: length 157.1
  TOP w0.076: 159.44,99.96 159.44,100 159.74,100.3 159.74,102.94 159.87,103.07 159.87,103.07
  TOP w0.127: 159.87,103.07 160.83,103.07 161.44,103.68 162.21,103.68 162.58,103.31 162.58,102.31 162.52,102.24 162.49,102.22 162.35,102.22 162.17,102.4 162.17,102.4 v2(161.98,102.59) ; 159.44,99.96 159.44,99.84 159.45,99.83 159.45,98.81 159.04,98.4 158.49,98.4 v2(158.29,98.2) ; C549.1 68.49,20.63 68.7,20.63 69.34,21.27 69.34,23.42 74.9,28.98 79.48,28.98 88.26,37.76 88.26,51.38 86.64,53.01 86.64,54.15 88.42,55.93 88.42,61.95 v2(88.67,62.2)
  IN1 w0.14: v2(158.29,98.2) 158.1,98.39 157.51,98.39 157.21,98.08 156.22,98.08 154.48,96.34 151.56,96.34 150.44,95.22 144.65,95.22 144.05,95.82 134.72,95.82 133.46,97.09 125.89,97.09 123.48,94.68 121.78,94.68 121.14,94.04 119.88,94.04 112.09,86.25 112.09,85.28 111.4,84.6 111.4,81.43 102.41,72.44 96.1,72.44 90.57,66.92 90.57,65.2 88.43,63.06 88.43,62.45 v2(88.67,62.2)
  BOTTOM w0.076: U25.E10 162.48,102.9 162.63,102.74 162.63,102.64 162.53,102.54 162.33,102.54 162.23,102.44 162.13,102.44 v2(161.98,102.59)
PCIE_RXP5_CARD_C: length 4.9
  TOP w0.127: U19.7 65.14,19.21 65.23,19.3 65.43,19.3 65.68,19.56 65.68,20.45 65.85,20.63 66.06,20.63 66.23,20.46 v1(66.23,20.1) 66.77,20.65 67.21,20.65 67.32,20.53 C549.2
PCIE_TXN3_WLAN: length 107.1
  TOP w0.127: C256.2 150.53,112.76 150.62,112.85 150.98,112.85 151.11,112.73 151.11,109.66 v2(150.84,109.39)
  IN1 w0.14: v2(150.84,109.39) 151.28,109.83 151.46,109.83 151.59,109.96 168.23,109.96 172.27,114 176.5,114 180.71,109.79 188.04,109.79 188.7,110.45 193.77,110.45 195.96,112.63 195.96,130.96 191.93,134.99 191.93,150.38 189.67,152.64 189.67,162.34 CN22.31
PCIE_TXN3_WLAN_C: length 10.8
  TOP w0.127: v2(150.2,109.36) 149.96,109.6 149.96,110.33 149.1,111.19 149.1,112.78 149.15,112.84 149.67,112.84 149.75,112.76 C256.1
  BOTTOM w0.076: U25.C29 150.58,104.33 150.58,104.56 150.37,104.77
  BOTTOM w0.127: v2(150.2,109.36) 150.2,109 151.08,108.13 151.08,106.99 150.37,106.28 150.37,104.77
PCIE_TXN4_LAN: length 177.3
  TOP w0.127: U8.14 22.28,119.96 22.38,120.06 22.38,120.38 22.31,120.44 22.31,121.43 31.27,130.38 31.27,139.83 49.09,157.66 52.86,157.66 54.34,159.14 54.58,159.14 55.67,160.22 75.28,160.22 75.56,159.94 82.22,159.94 117.65,124.51 118.99,124.51 122.52,120.98 127.15,120.98 130.96,124.79 130.96,124.97 v2(130.71,125.22)
  BOTTOM w0.127: v2(130.71,125.22) 130.99,125.5 130.99,125.81 131.34,126.16 132.68,126.16 133.04,125.81 133.86,125.81 v1(134.39,126.34) 134.9,125.83 140.94,125.83 146.53,120.24 146.53,115.93 147.39,115.06 148.33,115.06 C698.2
PCIE_TXN4_LAN_C: length 13.2
  BOTTOM w0.127: C698.1 149.79,115.19 150.21,115.19 150.49,114.9 150.49,113.48 150.19,113.17 150.19,112.42 150.45,112.16 v1(151,112.16) 151,111.4 151.61,110.8 151.61,110.33 152.27,109.67 152.27,109.11 151.71,108.55 151.71,106.91 151.05,106.25 151.05,105.22 U25.B29
PCIE_TXN5_CARD: length 174.7
  TOP w0.127: U19.4 65.12,18.01 65.2,17.93 68.2,17.93 71.12,20.85 71.12,23.05 75.53,27.46 80.12,27.46 89.79,37.13 89.79,48.27 90.05,48.53 90.05,50.35 89.83,50.58 89.83,52.73 90.05,52.95 90.05,57.44 90.79,58.18 90.79,71.2 89.95,72.04 89.95,73.42 87.37,76 86.19,76 82.45,79.74 82.45,90.32 101.24,109.12 101.24,110.8 105.31,114.86 108.58,114.86 109.35,114.1 118.67,114.1 119.56,114.99 129.56,114.99 130.55,115.98 140.09,115.98 140.65,116.53 140.69,116.57 145.58,116.57 145.85,116.84 147.39,116.84 147.72,116.51 147.72,116.13 v2(147.9,115.95)
  BOTTOM w0.127: C705.2 149.25,117.59 149.25,117.3 148.79,116.84 148,116.84 147.72,116.57 147.72,116.13 v2(147.9,115.95)
PCIE_TXN5_CARD_C: length 22.9
  BOTTOM w0.076: 154.77,107.93 154.75,107.92 154.75,107.86 154.79,107.82 154.79,106.02 155.02,105.79 155.02,105.32 154.82,105.12 154.82,104.7 154.96,104.56 154.96,104.45 U25.C23
  BOTTOM w0.127: C705.1 149.73,118.75 149.58,118.59 149.15,118.59 149.02,118.72 149.02,119.54 149.27,119.79 152.15,119.79 154.3,117.63 154.3,113.91 153.77,113.38 153.77,112.7 153.59,112.52 v1(153.25,112.52) 153.9,111.87 153.9,110.01 154.75,109.15 154.75,107.98 154.77,107.97 154.77,107.93
PCIE_TXP3_WLAN: length 107.1
  TOP w0.127: C244.2 150.53,113.22 150.67,113.08 151.08,113.08 151.33,112.82 151.33,109.66 v2(151.6,109.39)
  IN1 w0.14: v2(151.6,109.39) 151.6,109.59 151.7,109.69 168.34,109.69 172.39,113.74 176.39,113.74 180.6,109.52 188.15,109.52 188.81,110.18 193.88,110.18 196.23,112.52 196.23,131.07 192.2,135.1 192.2,150.49 189.93,152.75 189.93,162.34 CN22.33
PCIE_TXP3_WLAN_C: length 10.9
  TOP w0.127: C244.1 149.35,113.07 149.06,113.07 148.87,112.88 148.87,111.1 149.73,110.24 149.73,109.64 v2(149.44,109.36)
  BOTTOM w0.127: U25.B30 150.14,104.55 150.14,106.37 150.85,107.08 150.85,108.03 149.98,108.9 149.97,108.9 149.52,109.36 v2(149.44,109.36)
PCIE_TXP4_LAN: length 177.3
  TOP w0.127: U8.13 22.68,119.83 22.61,119.91 22.61,120.47 22.54,120.53 22.54,121.33 31.49,130.29 31.49,139.74 49.19,157.43 52.96,157.43 54.43,158.91 54.68,158.91 55.77,159.99 75.18,159.99 75.46,159.72 82.12,159.72 117.56,124.28 118.9,124.28 122.43,120.75 127.24,120.75 131.19,124.7 131.19,124.94 v2(131.47,125.22)
  BOTTOM w0.127: C701.2 148.73,114.74 148.64,114.83 147.3,114.83 146.3,115.83 146.3,120.15 140.85,125.6 134.92,125.6 v1(134.39,125.07) 133.88,125.58 132.94,125.58 132.59,125.93 131.44,125.93 131.21,125.71 131.21,125.48 v2(131.47,125.22)
PCIE_TXP4_LAN_C: length 13.2
  BOTTOM w0.127: C701.1 149.38,114.44 149.38,114.81 149.53,114.96 150.11,114.96 150.27,114.81 150.27,113.57 149.96,113.27 149.96,112.33 150.42,111.87 150.42,111.58 v1(150.11,111.26) 150.82,111.26 151.38,110.7 151.38,110.24 152.05,109.58 152.05,109.21 151.55,108.71 151.55,108.71 151.48,108.65 151.48,107 150.67,106.19 150.67,105.92 150.82,105.77 150.82,105.65 U25.A29
PCIE_TXP5_CARD: length 174.6
  TOP w0.127: U19.3 65.11,17.61 65.21,17.7 68.29,17.7 71.35,20.76 71.35,22.95 75.62,27.23 80.21,27.23 90.02,37.03 90.02,48.17 90.28,48.44 90.28,50.44 90.05,50.67 90.05,52.63 90.28,52.86 90.28,57.35 91.02,58.08 91.02,71.29 90.18,72.13 90.18,73.51 87.47,76.23 86.28,76.23 82.68,79.83 82.68,90.23 101.47,109.02 101.47,110.7 105.4,114.63 108.49,114.63 109.25,113.87 118.77,113.87 119.66,114.76 129.66,114.76 130.65,115.75 140.18,115.75 140.74,116.31 140.78,116.35 145.67,116.35 145.94,116.61 147.3,116.61 147.5,116.42 147.5,116.15 147.29,115.95 v2(147.14,115.95)
  BOTTOM w0.127: C711.2 149.02,117.62 149.02,117.39 148.7,117.07 147.9,117.07 147.5,116.66 147.5,116.17 147.27,115.95 v2(147.14,115.95)
PCIE_TXP5_CARD_C: length 23
  BOTTOM w0.076: U25.C22 155.12,103.84 155.12,104.63 154.98,104.77 154.98,105.05 155.18,105.25 155.18,105.85 154.95,106.09 154.95,107.84 154.98,107.87
  BOTTOM w0.127: 154.98,107.87 154.98,109.25 154.13,110.1 154.13,112.13 v1(154.52,112.52) 154,113.04 154,113.28 154.53,113.82 154.53,117.73 152.25,120.02 149.17,120.02 148.79,119.63 148.79,119.08 C711.1
PCIE_WAKE#: length 463.9
  TOP w0.127: v2(177.95,73.46) 177.82,73.58 177.82,75.62 178.34,76.13 R259.1 179.73,76.38 182.98,79.63 182.98,82.6 184.37,83.99 184.37,88.87 186.06,90.56 187.21,90.56 190.69,94.04 190.69,95.07 192.05,96.43 192.05,106.44 190.9,107.59 190.9,110.09 190.14,110.86 190.14,112.63 191.21,113.69 191.21,115.8 v2(191.13,115.88) ; v2(34.66,71.54) 34.8,71.68 35.46,71.68 35.51,71.73 U11.17 ; v2(172.57,154.1) 172.82,154.1 173.2,153.72 EC12.1 173.24,154.12 173.35,154.23 Q5.3 ; v2(88.95,20.52) 88.97,20.5 88.97,20.4 90.4,18.97 90.4,16.56 89.38,15.55 79.27,15.55 78.87,15.14 72.16,15.14 69.65,12.62 v1(65.56,12.62) 64.41,12.62 64.29,12.75 R407.1 v2(64.96,13.25) ; R146.2 17.17,118.57 v2(16.91,118.82)
  IN1 w0.14: v2(172.57,154.1) 173.66,154.1 174.53,153.23 180.44,153.23 187.42,146.25 187.42,133.19 191.13,129.48 v2(191.13,115.88) ; v2(88.95,20.52) 89.25,20.52 89.28,20.5 104.72,20.5 104.77,20.45 105.48,20.45 106.86,21.82 116.28,21.82 117.07,21.03 128.29,21.03 129.49,22.23 165.4,22.23 165.74,22.57 169.25,22.57 169.58,22.9 170.25,23.57 174.81,23.57 180.22,28.98 180.22,37.76 180.9,38.44 180.9,41.76 181.05,41.91 181.05,48.41 180.74,48.71 180.74,55.25 181.05,55.55 181.05,62.12 180.22,62.96 180.22,63.9 179.75,64.37 179.75,69.91 179.04,70.62 179.04,70.99 178.38,71.65 178.38,73.03 v2(177.95,73.46) 177.54,73.86 177.54,74.4 176.03,75.92 174.8,75.92 169.12,81.6 169.12,83.17 167.97,84.33 167.97,86.72 167.48,87.21 167.48,88.96 166.96,89.48 166.57,89.48 165.93,90.12 v2(165.47,90.12) ; v2(34.66,71.54) 34.05,71.54 31.81,69.3 31.81,63.96 25.17,57.33 25.17,55.6 18.16,48.59 18.16,40.93 21.07,38.02 21.07,30.82 24.14,27.75 24.14,23.35 32.06,15.42 42.44,15.42 43.97,13.89 62.63,13.89 62.75,13.78 64.43,13.78 v2(64.96,13.25)
  BOTTOM w0.127: v2(165.47,90.12) 165.28,89.94 U25.AJ5 ; v2(34.66,71.54) 31.39,74.8 31.39,77.42 31.55,77.58 31.55,79.52 31.93,79.89 31.93,88.34 32.15,88.57 32.15,89.99 31.37,90.78 31.37,93.15 26.36,98.16 26.36,100.78 21.72,105.43 21.72,108.26 20.88,109.09 20.88,114.15 19.76,115.27 19.76,116.84 17.78,118.82 v2(16.91,118.82)
PCIE_WAKE#_R: length 6.2
  TOP w0.127: v1(16.07,118.89) 16.45,119.27 17.19,119.27 17.29,119.16 17.92,119.16 18.37,118.72 R146.1 19.1,117.84 19.1,117.4 19.6,116.89 20.14,116.89 20.22,116.82 U8.21
PD#: length 58.9
  TOP w0.127: v2(171.17,9.55) 171.35,9.73 Q29.3 171.53,10.78 R421.1 R420.2 171.53,13.26 171.28,13.51 171.28,14.75 170.99,15.04 D11.2 170.33,15.04 169.71,15.66 166.77,15.66 166.14,15.66 165.3,14.82 D14.1 163.85,14.82 163.82,14.79 R404.2 ; U20.47 182.18,17.37 182.25,17.45 v2(182.25,17.76) 182.16,17.76 181.43,18.49 181.43,19.09 181.04,19.48 181.04,22.62 180.94,22.72 180.94,23.86 182.04,24.96 182.04,28.65 v1(182.27,28.88) 182.78,29.39 184.28,29.39 184.76,29.87 184.76,32.49 184.22,33.02 183.62,33.02 183.01,33.63 183.01,34.66 R344.2
  TOP w0.254: R344.2 183.5,34.94 183.79,35.23 183.79,36.01 184.05,36.26 184.05,36.66 184.27,36.88 U14.1 184.27,38.98 184.43,39.14 184.78,39.14 184.92,39.01 U14.2
  BOTTOM w0.127: v2(182.25,17.76) 182.25,14.18 181.93,13.85 181.93,13.82 179.84,11.74 179.72,11.74 179.66,11.67 178.04,11.67 176.78,10.41 172.03,10.41 v2(171.17,9.55)
PD#_R: length 8.2
  TOP w0.254: 161.06,14.02 161.07,14.01 R404.1 164.59,14.01 D14.3 165.69,13.03 167.17,13.03 R627.2 R7484.1
  vias: v1(159.87,13.89)
PIRQC#: length 22.2
  IN2 w0.14: v3(166.26,97.92) 166.71,98.37 168.63,98.37 169.84,99.58 169.84,100.78 171.16,102.1 177.53,102.1 178.38,101.24 178.38,100.69 178.71,100.36 180.23,100.36 v2(182.12,98.46)
  BOTTOM w0.089: U25.N4 166.26,98.03 v3(166.26,97.92)
  BOTTOM w0.127: R516.1 183.25,99.1 182.61,98.46 v2(182.12,98.46)
PIRQD#: length 5.8
  BOTTOM w0.076: 169.64,98.32 168.35,98.32 168.03,98 167.56,98 U25.N2
  BOTTOM w0.127: R518.1 171.84,99.37 171.75,99.45 171.04,99.45 170.33,98.75 170.07,98.75 169.64,98.32
PLTRST#: length 639
  TOP w0.127: v2(34.66,69.51) 35.69,69.51 35.91,69.73 U11.22 ; R258.2 169.95,77.96 169.95,78.69 v2(170.51,79.25) ; U19.1 65.18,16.81 65.94,16.05 EC58.1 v2(66.7,14.92) 66.71,14.91 v1(67.59,14.91) 68.5,14.91 70.02,16.43 EC59.1 75.38,16.26 78.26,16.26 78.95,16.94 79.4,16.94 79.91,17.45 ; 79.91,17.45 79.91,21.39 81.56,23.04 v2(81.56,26.16) 81.15,26.57 R365.2 ; 79.91,17.45 80.44,16.92 82.49,16.92 82.88,17.3 U18.16 ; CN22.17 183.8,162.11 181.25,159.56 v2(181.25,158.55) ; R262.1 78.17,75.75 78.32,75.61 78.32,74.61 v2(77.88,74.17) ; v2(167.92,157.28) 166.5,155.85 v2(166.5,153.21) ; U8.19 19.91,117.62 v2(19.86,117.67)
  IN1 w0.076: 166.23,88.35 165.89,88.7 165.89,89.21 165.64,89.45 164.99,89.45 164.7,89.73 164.67,89.73 164.27,90.13 v2(164.17,90.13)
  IN1 w0.14: v2(31.9,75.79) 32.12,76 43.09,76 43.49,76.41 54.52,76.41 54.73,76.2 62.92,76.2 66.29,72.83 76.54,72.83 v2(77.88,74.17) ; v2(32.64,94.82) 32.65,94.81 39.07,94.81 39.45,94.43 50.33,94.43 51.46,95.56 54.94,95.56 55.68,96.29 78.33,96.29 103.22,121.18 107.72,121.18 109.28,119.62 109.48,119.62 110.51,118.59 113.74,118.59 115.72,120.57 126.26,120.57 128.93,123.24 130.83,123.24 131.21,122.86 131.21,120.2 133.36,118.05 140.68,118.05 141.91,119.28 146.44,119.28 147.41,120.25 155.02,120.25 156.2,119.07 166.68,119.07 168.86,121.26 168.86,128.72 166.5,131.09 v2(166.5,153.21) ; v2(81.56,26.16) 82.2,26.16 82.94,25.42 100.13,25.42 100.7,24.85 106.54,24.85 108.51,22.88 115.9,22.88 116.48,22.3 120.52,22.3 120.72,22.1 121.75,22.1 122.13,22.49 127.74,22.49 128.1,22.85 165.13,22.85 165.37,23.09 169.03,23.09 169.36,23.42 170.03,24.09 174.59,24.09 179.7,29.2 179.7,41.3 180.53,42.13 180.53,48.19 180.21,48.51 180.21,55.45 180.53,55.77 180.53,61.91 179.23,63.21 179.23,66.91 178.52,67.61 178.52,70.78 177.73,71.57 177.73,71.95 177.32,72.36 177.32,74.31 175.93,75.69 174.71,75.69 171.15,79.25 v2(170.51,79.25) 170.51,79.38 168.63,81.25 168.63,82.91 167.66,83.87 167.66,86.61 167.27,87 166.74,87 166.49,87.25 166.49,88.1 166.23,88.35 ; v2(66.7,14.92) 66.3,15.32 57.34,15.32 56.59,14.57 44.64,14.57 42.99,16.21 34.82,16.21 30.32,20.71 28.31,20.71 25.11,23.91 25.11,28.61 23.49,30.23 23.49,37.17 18.68,41.98 18.68,47.4 20.98,49.7 21.24,49.7 25.69,54.15 25.69,57.06 32.33,63.7 32.33,67.26 34.58,69.51 v2(34.66,69.51) ; v2(167.92,157.28) 176.17,157.28 177.44,158.55 v2(181.25,158.55)
  BOTTOM w0.127: v2(164.17,90.13) 163.98,90.32 U25.AG7 ; v2(181.25,158.55) 181.39,158.69 183.8,158.69 184.16,159.05 185.32,159.05 185.8,158.57 CN22.22 ; v2(19.86,117.67) 20.34,117.19 20.34,115.54 22.5,113.39 22.5,108.89 22.22,108.61 22.22,105.64 26.87,100.99 26.87,100.59 v2(32.64,94.82) 33.3,94.16 33.3,87.05 32.52,86.27 32.52,76.16 32.15,75.79 v2(31.9,75.79) 31.9,75.08 35.13,71.86 35.13,71.35 34.66,70.88 v2(34.66,69.51)
PM_BATLOW#: length 22.4
  TOP w0.127: v3(168.43,86.58) 167.79,87.22 167.79,88.17 167.92,88.3 167.92,88.72 168.3,89.1 168.88,89.1 169.88,90.1 170.93,90.1 172.93,92.1 173.79,92.1 174.83,93.14 R178.2 177.43,93.4 177.64,93.6 178.66,93.6 179.18,93.08 181.78,93.08 181.99,93.29 182.43,93.29 R168.1
  BOTTOM w0.076: v3(168.43,86.58) 168.41,86.6 167.03,86.6 166.92,86.71 166.27,86.71 U25.AN4
PM_EXTTS#0: length 75.9
  TOP w0.127: v2(175.11,36.75) 175.41,37.06 v1(175.41,37.64) R334.2 ; v2(122.22,24.27) 122.22,24.21 121.92,23.9 120.52,23.9 118.57,21.95 U16.6
  IN2 w0.14: v2(122.22,24.27) 122.22,24.66 122.65,25.09 133.87,25.09 134.21,25.43 166.14,25.43 168.24,27.53 172.82,27.53 173.77,28.48 v2(173.77,28.73) 173.95,28.91 173.95,33.23 174.71,34 174.71,36.36 v2(175.11,36.75)
  BOTTOM w0.127: v2(173.77,28.73) 173.85,28.64 JDIM2.198 ; v2(175.11,36.75) 175.04,36.75 174.15,37.64 174.15,38.14 173.85,38.44 JDIM1.198
PM_THRMTRIP#: length 142.1
  TOP w0.127: v2(127.13,104.22) v1(127.91,103.43) 129.57,101.77 v2(132.32,101.77) ; v2(56.72,81.36) 56.72,81.41 57.17,81.86 C328.1 57.74,82.72 58.09,83.06 58.09,84.86 57.05,85.9 ; R184.1 152.94,91.23 v2(152.77,91.06)
  IN1 w0.14: v2(56.72,81.36) 57.63,82.27 65.18,82.27 66.55,83.64 71.28,83.64 72.11,84.47 74.33,84.47 74.85,84.98 76.51,84.98 78.46,83.03 81.07,83.03 82.84,81.26 86.99,81.26 87.44,81.71 98.7,81.71 99.13,81.28 100.66,81.28 101.42,80.52 102.16,80.52 105.31,83.67 105.31,89.33 108.96,92.99 109.52,92.99 110.2,93.66 110.2,95.62 111.78,97.21 111.78,100.03 112.72,100.97 116.99,100.97 117.4,101.37 121.87,101.37 124.71,104.22 v2(127.13,104.22)
  BOTTOM w0.076: v2(132.32,101.77) 132.32,101.23 132.05,100.97 131.8,100.97 131.54,100.71 131.54,98.91 131.72,98.73 131.98,98.73 132.23,98.48 132.23,98.22 132.1,98.1 132.1,97.97 132.23,97.84 132.23,96.95 132.21,96.92 132.21,96.65 132.23,96.62 132.23,95.65 132.21,95.62 132.21,95.35 132.23,95.32 132.23,94.87 132.58,94.51 132.67,94.51 132.87,94.32 132.87,94.01 132.56,93.7 132.51,93.7 132.21,93.4 132.21,92.91 132,92.71 131.8,92.71 131.54,92.46 131.54,91.39 131.71,91.22 132.01,91.22 ; U25.D60 131.05,103.71 130.7,104.06 130.5,104.06 130.22,103.78 129.79,103.78 129.71,103.87 129.12,103.87 128.83,104.17
  BOTTOM w0.127: v2(152.77,91.06) 152.3,91.54 147.26,91.54 146.84,91.11 143.66,91.11 143.13,90.58 133.99,90.58 133.88,90.48 133.5,90.48 133.37,90.6 132.99,90.6 132.97,90.58 132.66,90.58 132.01,91.22 ; 128.83,104.17 128.78,104.22 v2(127.13,104.22)
PN_BLON: length 7.5
  TOP w0.127: v1(44.52,167.95) 44.4,168.07 R5.2 43.47,168.19 42.95,168.71 41.81,168.71 41.58,168.94 41.58,169.44 41.3,169.72 40.7,169.72 40.27,170.15 R7.2 40.27,170.86 40.49,171.07 D1.2
PROC_OPI_RCOMP: length 5.5
  BOTTOM w0.178: 159.29,81.82 159.29,82.88 U25.AY15
  BOTTOM w0.254: R584.2 159.31,77.61 v1(159.31,78.54) 159.29,78.56 159.29,81.82
PROCHOT#: length 6.8
  BOTTOM w0.127: v2(123.14,99.37) 123.65,99.87 124.37,99.87 R517.2 126.64,99.37 127.12,99.85 129.27,99.85 U25.K63
PROCPWRGD: length 11.1
  BOTTOM w0.076: 130.16,105.91 130.2,105.87 130.65,105.87 130.86,105.66 130.86,105.21 130.93,105.14 130.93,104.3 U25.C61
  BOTTOM w0.127: 130.16,105.91 130.1,105.97 129.21,105.97 128.22,104.98 123.75,104.98 v1(123.34,104.57) 123.09,104.32 R495.2
PWR_DEBUG: length 104
  TOP w0.102: 77.56,65.39 v2(77.54,65.38)
  TOP w0.127: CN8.53 77.56,65.39 ; v2(111.19,95.49) 111.19,95.26 111.66,94.79 v1(111.66,93.27) 111.66,92.96 v2(112.2,92.42)
  IN2 w0.14: v2(77.54,65.38) 76.14,65.38 75.44,64.67 69.23,64.67 68.76,65.14 68.76,67.22 68.14,67.84 68.14,69.52 68.84,70.22 68.84,70.39 69.44,71 69.44,72.75 72.84,76.15 74.81,76.15 76.55,77.89 77.56,77.89 79.83,80.16 95.78,80.16 98.54,82.91 101.08,82.91 103.53,85.36 103.53,87.4 104.8,88.67 104.8,90.3 109.3,94.79 110.01,94.79 110.7,95.49 v2(111.19,95.49) 111.19,96 112.21,97.02 112.21,99.86 113.18,100.84 116.46,100.84 116.64,101.02 119.56,101.02 120.19,101.65 122.58,101.65 122.68,101.55 128.26,101.55 v2(128.85,100.96)
  BOTTOM w0.127: R556.1 R555.2 112.5,92.72 v2(112.2,92.42) ; U25.H59 131.55,101.7 129.86,101.7 129.62,101.46 129.62,101.2 129.63,101.19 129.63,101.13 129.45,100.96 v2(128.85,100.96)
PWR_LED#: length 119.6
  TOP w0.127: U11.24 35.64,68.93 v2(35.59,68.98) ; v2(29.36,169.85) 28.85,170.36 25.93,170.36 25.17,171.12 25.17,171.88 24.51,172.54 Q1.2 23.15,172.54 23.14,172.53 C70.2 21.11,172.53 v1(21.11,172.52)
  BOTTOM w0.127: v2(29.36,169.85) 30.06,169.15 30.06,153.15 29.29,152.38 29.29,126.06 25.23,122 25.23,115.07 27.13,113.18 27.13,100.96 33.55,94.54 33.55,86.94 32.78,86.17 32.78,77.03 36.19,73.62 36.19,69.58 v2(35.59,68.98)
R_SPK+: length 291.3
  IN1 w0.635: 115.67,10.06 121.61,10.06 123.59,12.03 139.91,12.03 141.83,13.95 154.06,13.95 154.25,14.15 157.59,14.15 157.59,14.15 161.49,14.15 162.38,13.26 166.31,13.26 168.17,11.39 172.29,11.39 172.66,11.76 175.64,11.76 177.6,13.72 178.05,13.72 178.55,13.72 179.26,14.43 180.52,14.43 183.03,16.94 183.03,16.94
  IN2 w0.635: v5(83.62,172.92) 86.03,170.51 86.03,167.55 85.77,167.3 85.77,167.3 85.06,166.59 85.06,154.23 99.11,140.18 99.11,110.69 79.37,90.96 67.29,90.96 61.84,85.5 61.84,71.08 62.58,70.33 62.58,62.89 72.4,53.08 73.19,53.08 74.7,51.57 74.7,49.67 79.98,44.39 81.02,43.35 81.02,41.63 83.7,38.95 84.22,38.95 88.55,34.62 89.24,34.62 89.98,34.62 91.02,33.58 92.73,31.86 92.73,31.1 96.29,27.54 96.29,25.08 96.29,19.01 104.15,11.15 112.34,11.15
  vias: v2(113.66,10.08) v2(114.3,10.03) v2(183.72,18.47) v2(183.72,17.83)
R_SPK+_R: length 20.6
  TOP w0.635: L3.1 87.9,172.9 C25.2 90.2,172.89 90.83,172.26 v1(92.81,172.26) 102.92,172.26 104.71,174.05 CN3.1
R_SPK-: length 293.1
  IN1 w0.635: 183.49,19.15 182.59,19.15 181.25,17.81 181.25,16.56 180.01,15.32 178.89,15.32 178.18,14.61 177.21,14.61 175.26,12.65 172.29,12.65 171.92,12.28 168.54,12.28 166.5,14.33 162.78,14.33 162.06,15.04 153.88,15.04 153.69,14.84 141.46,14.84 139.55,12.92 123,12.92 121.12,11.04 113.93,11.04 113.9,11.01 113.69,11.01
  IN2 w0.635: v5(83.44,171.5) 85.14,169.8 85.14,167.92 84.17,166.95 84.17,153.57 98.04,139.7 98.04,111.58 78.61,92.15 67.05,92.15 60.82,85.92 60.82,70.66 61.69,69.78 61.69,63.26 61.69,63.26 61.69,62.53 72.03,52.19 72.32,52.19 73.73,50.77 73.73,49.38 79.61,43.5 79.61,43.5 80.14,42.98 80.14,41.26 83.34,38.06 83.85,38.06 88.18,33.73 89.61,33.73 90.13,33.21 91.84,31.5 91.84,30.73 95.4,27.17 95.4,25.45 95.4,25.45 95.4,18.64 103.86,10.19 111.25,10.19
  vias: v2(112.14,10.21) v2(112.77,10.16) v2(184.35,18.47) v2(184.35,17.83)
R_SPK-_R: length 20.4
  TOP w0.635: L4.1 87.57,171.5 87.82,171.26 C30.2 88.55,171.26 88.67,171.37 v1(91.03,171.37) 103.54,171.37 104.97,172.8 CN3.2
REGN6V: length 18.9
  TOP w0.127: v2(88.92,183.34) 88.71,183.55 PR217.2
  TOP w0.254: PU1.16 93.1,179.62 93.65,179.07 93.65,178.6 PC239.2 v2(94.28,178.76)
  TOP w0.508: PC239.2 95.46,177.97 v1(95.92,177.51) 97.44,177.51 PD4.2
  IN1 w0.254: v2(88.92,183.34) 88.92,179.73 91.29,177.37 93.62,177.37 94.28,178.02 v2(94.28,178.76)
RF_LINK#: length 232.4
  TOP w0.127: U11.109 46,80.62 46.12,80.75 46.12,86.32 47,87.19 50.57,87.19 50.93,87.55 v1(51.33,87.55) 51.46,87.55 52.03,88.13 v2(52.03,90.77)
  IN1 w0.14: v2(52.03,90.77) 52.57,90.77 52.66,90.68 56.3,90.68 56.58,90.96 66.55,90.96 68.2,92.61 80.27,92.61 103.22,115.56 108.85,115.56 110.77,113.64 116.13,113.64 117.91,115.42 125.15,115.42 129.46,111.11 143.31,111.11 144.15,111.95 160.58,111.95 161.91,113.28 168.34,113.28 171.33,116.28 177.65,116.28 181.19,112.74 188.53,112.74 190.57,114.78 191.41,114.78 192.1,115.48 192.1,130.15 188.62,133.63 v2(188.62,147.65)
  IN2 w0.14: v2(188.62,147.65) 187.01,147.65 186.71,147.94 186.71,152.37 192.84,158.5 v2(195.18,158.5)
  BOTTOM w0.127: v2(188.62,147.65) 192.84,151.87 R458.2
RF_OFF_PCH: length 85.2
  TOP w0.127: Q3.2 193.23,159.19 192.86,159.56 192.86,159.94 191.95,160.86 190.19,160.86 188.44,159.11 188.44,155.24 190.68,153.01 190.68,147.83 187.37,144.53 187.37,114.76 v1(186.71,114.1) 186.45,113.84 186.45,113.04 185.95,112.53 185.95,110.67 187.09,109.53 187.09,108.38 187.65,107.82 187.65,107.28 187.78,107.15 187.78,106.27 187.98,106.07 187.98,98.83 186.61,97.46 185.27,97.46 183.86,96.05 R177.1 184.07,95.32 184.07,94.56 183.79,94.28 183.79,93.52 183.31,93.04 182.09,93.04 181.88,92.83 178.92,92.83 178.61,93.14 R178.1
RF_OFF_PCH_R: length 22.7
  TOP w0.127: R177.2 184.85,95.32 R172.1 184.82,94.46 184.55,94.46 184.1,94.01 184.1,93.43 183.46,92.79 182.2,92.79 181.99,92.58 178.82,92.58 178.82,92.57 175.02,92.57 v1(174.19,91.75) 173.84,91.39 172.58,91.39 171.03,89.84 170.05,89.84 169.13,88.92 v2(169.13,87.86)
  BOTTOM w0.076: v2(169.13,87.86) 168.73,87.47 168.21,87.47 168.17,87.51 167.56,87.51 U25.AM2
RSMRST#: length 325.5
  TOP w0.127: U11.119 42,81.78 EC25.2 41.31,81.2 v2(41.15,81.2)
  IN1 w0.14: v2(29.74,71.58) 29.94,71.58 30.76,70.76 30.76,69.27 31.28,68.74 31.28,64.28 24.65,57.65 24.65,55.81 17.64,48.8 17.64,40.72 20.46,37.9 20.46,30.39 23.51,27.34 23.51,23.24 32.78,13.97 36.93,13.97 37.84,14.88 42.09,14.88 43.66,13.31 62.52,13.31 64.38,11.46 71.42,11.46 72.26,10.62 88.67,10.62 89.28,11.23 95.35,11.23 95.48,11.1 110.51,11.1 112.55,13.13 113.82,13.13 v2(114.45,13.77)
  BOTTOM w0.076: U25.AW6 164.25,83.24 164.25,81.92 164.64,81.53 165.09,81.53 166.24,80.37 167.6,80.37 167.93,80.05 167.93,79.82
  BOTTOM w0.127: v2(41.15,81.2) 39.01,79.06 39.01,76.63 36.95,74.57 36.95,68.6 36.66,68.31 36.66,67.28 35.19,65.8 34.51,65.8 33.42,66.89 33.42,67.74 v1(32.41,68.76) 29.74,71.43 v2(29.74,71.58) ; 167.93,79.82 167.93,77.75 R578.1 R579.2 169.47,77.23 169.47,75.66 169.59,75.55 169.59,75 169.44,74.85 169.44,64.31 174.38,59.38 176.48,59.38 177.09,58.77 178.15,58.77 179.42,57.49 179.42,45.79 181.05,44.17 181.05,27.13 176.59,22.67 173.36,22.67 172.66,21.97 166.93,21.97 165.7,20.74 165.29,20.74 164.38,19.82 162.83,19.82 162.21,20.45 159.79,20.45 158.1,18.76 154.26,18.76 153.46,19.56 147.58,19.56 142.75,19.56 140.83,17.64 121.27,17.64 118.03,14.4 114.83,14.4 114.45,14.02 v2(114.45,13.77)
RTC_RST#: length 41.6
  TOP w0.127: v2(171.14,74.02) 171.13,74.02 170.53,74.02 C367.1 170.21,74.35 R265.2 169.16,73.71 168.82,73.36 R277.2 168.82,72.7 168.43,72.31 168.43,68.76 171.73,65.45 CN9.9 173.87,65.45 174.01,65.31 175.41,65.31 v1(175.44,65.28) 175.64,65.28 175.66,65.31 177.7,65.31 178.03,64.98 178.03,64.36 177.47,63.81 Q19.3
  IN1 w0.14: v2(171.14,74.02) 170.66,74.02 169.67,75 169.67,75.48 169.15,76 168.72,76 168.23,76.49 168.23,77.03 167.29,77.96 166.57,77.96 165.1,79.44 164.96,79.44 164.28,80.12 164.28,83.22 163.7,83.8 163.7,85.12 v2(163.52,85.31)
  BOTTOM w0.076: v2(163.52,85.31) 163.75,85.07 U25.AU7
  BOTTOM w0.127: J1.1 172.54,76.04 172.54,74.98 171.58,74.02 v2(171.14,74.02)
RTC_X1: length 20.6
  TOP w0.127: Y4.1 174.16,73.76 174.91,74.51 R582.2 C369.2 R573.1 176.39,76.22 v2(176.39,77.06)
  BOTTOM w0.076: 168.81,81.04 166.95,81.04 165.66,82.33 165.66,83.17 U25.AW5
  BOTTOM w0.127: v2(176.39,77.06) 176.55,77.23 176.55,78.26 176.12,78.69 172.48,78.69 170.14,81.04 168.81,81.04
RTC_X2: length 18.9
  TOP w0.127: Y4.2 176.66,74.28 176.94,74.56 C360.2 R573.2 176.96,76.01 v2(176.96,76.76)
  BOTTOM w0.076: 168.68,80.7 168.51,80.87 166.88,80.87 165.33,82.43 U25.AY5
  BOTTOM w0.127: v2(176.96,76.76) 176.73,76.53 176.24,76.53 175.94,76.83 TP35.1 175.76,78.19 172.27,78.19 169.93,80.53 168.85,80.53 168.68,80.7
RTS5237_AV12: length 11.3
  TOP w0.203: 60.96,21.68 61.78,20.86 U19.14 ; U19.10 63.38,20.89 63.55,21.06 63.96,21.06 64.54,21.64
  TOP w0.508: v2(62.15,22.52) C526.2 61.24,22.52 60.99,22.78 C525.2 60.35,22.47 60.96,21.86 60.96,21.68 ; v2(63.83,21.62) 63.83,22 64.35,22.52 C527.1 64.54,21.64
  BOTTOM w0.508: v2(62.15,22.52) 62.77,22.52 v1(63.02,22.28) 63.68,21.62 v2(63.83,21.62)
RTS5237_GPIO: length 3.4
  TOP w0.127: v2(63.43,13.76) 62.52,13.76 R406.1 62.25,14.53 62.18,14.6 U19.28
RTS5237_RREF: length 4.8
  TOP w0.203: U19.9 63.78,20.16 63.9,20.04 64.29,20.04
  TOP w0.305: 64.29,20.04 64.59,20.35 64.59,20.71 v1(64.92,21.04) 65.37,21.48 65.37,22.08 C528.2 R372.1
S5_ON: length 89.5
  TOP w0.127: R228.2 52.17,81.92 50.98,81.92 50.63,81.58 50.24,81.58 49.6,80.93 U11.100 49.6,78.15 46.82,75.37 46.82,73.37 47.61,72.58 v2(47.61,68.81) ; v2(34.31,56.19) 33.55,55.42 33.55,53.12 31.39,50.96 31.39,43.87 v1(30.88,43.36) 30.88,42.86 31.9,41.84 37.31,41.84 39.9,44.44 39.9,45.77 40.16,46.03 41.04,46.03 42.06,45.01 v2(43.33,45.01) 46.4,48.08 54.19,48.08 55.31,49.21 56,49.21 56.44,48.77 57.51,48.77 57.64,48.63 PR112.1
  BOTTOM w0.127: PR185.2 v2(43.33,45.01) ; v2(47.61,68.81) 47.57,68.81 47.55,68.83 43.41,68.83 42.47,69.77 40.28,69.77 39.7,69.2 39.7,67.4 38.07,65.77 37.49,65.77 36.93,65.2 36.93,64.62 34.31,62.01 v2(34.31,56.19)
SATA3GP: length 9.3
  BOTTOM w0.127: R550.1 176.05,92.75 175.87,92.57 174.58,92.57 173.93,91.92 171.93,91.92 171.09,92.76 v1(170.71,92.76) 170.67,92.8 168.26,92.8 168.01,93.05 U25.AC1
SATA_LED#: length 111.1
  TOP w0.127: v2(201.52,28.19) 201.97,27.75 201.97,26 200.22,24.25 CN14.19
  BOTTOM w0.076: U25.U3 166.82,96.01 167.07,95.75 168.1,95.75 168.16,95.7 168.9,95.7 169.46,96.25 170.49,96.25 170.61,96.13
  BOTTOM w0.127: 170.61,96.13 170.7,96.04 170.96,96.04 171.5,96.58 173.37,96.58 173.56,96.39 173.56,96.2 174.01,95.74 177,95.74 R536.1 177.57,96.19 178.71,95.05 178.71,93.74 180.17,92.28 180.17,91.58 181.44,90.3 181.44,88.51 182.2,87.75 182.2,83.53 180.89,82.22 179.91,82.22 179.42,82.22 179.25,82.04 179.25,78.95 179.06,78.76 179.06,76.46 179.3,76.21 179.3,72.11 178.8,71.62 178.8,68.95 179.06,68.7 179.06,66.15 178.61,65.7 178.61,63.55 182.04,60.12 182.04,54.71 184.5,52.25 192.63,52.25 193.55,51.33 193.55,49.55 194.81,48.3 201.61,48.3 203.02,46.89 203.02,33.5 v1(202.08,32.56) 201.52,32 v2(201.52,28.19) 201.72,28 EC78.1
SATA_RCOMP: length 10.9
  BOTTOM w0.127: U25.C12 160.8,105.07 160.48,105.39 160.48,106.3 161.07,106.9 161.07,111.96 162.05,112.94 v1(162.05,113.18) 162.05,113.21 162.2,113.36 R485.2
SATA_RXN0: length 97.7
  TOP w0.127: v2(196.49,39.5) 196.67,39.68 196.99,39.68 197.12,39.55 C794.2
  IN1 w0.14: v2(196.49,39.5) 196.38,39.61 195.79,39.61 195.46,39.94 195.46,42.1 195.64,42.27 195.64,47.59 197.66,49.62 197.66,57.68 197.33,58.01 197.33,70.11 195.41,72.03 195.41,77.2 195.83,77.62 195.83,79.35 193.87,81.31 193.87,82.3 192.91,83.26 192.91,89.94 193.41,90.44 193.41,92.29 192.02,93.68 191.95,93.75 191.95,99.5 191.35,100.09 191.35,101.36 188.94,103.77 188.14,103.77 187.6,103.23 184.63,103.23 184.37,103.48 181.03,103.48 180.36,102.82 180.28,102.74 168.62,102.74 167.52,101.64 166.34,101.64 165.62,100.91 165.05,100.91 v2(164.83,100.69)
  BOTTOM w0.127: U25.J5 165.29,100.47 165.06,100.69 v2(164.83,100.69)
SATA_RXN0_17: length 2.2
  TOP w0.127: HD17.5 199.15,39.25 199.02,39.39 198.74,39.39 198.44,39.69 198.29,39.69 C794.1
SATA_RXN1: length 110.8
  TOP w0.127: v2(84.69,62.03) 84.44,62.28 83.27,62.28 82.99,62.56 82.61,62.56 R295.2
  IN1 w0.14: v2(164.72,99.7) 164.31,99.29 164.03,99.29 163.81,99.07 162.98,99.07 162.56,98.65 160.9,96.99 157.22,96.99 156.28,96.05 155.38,96.05 154.75,95.43 151.94,95.43 150.4,93.89 144.36,93.89 143.64,94.61 134.59,94.61 133.46,95.74 125.84,95.74 123.86,93.77 122.16,93.77 121.52,93.13 120.26,93.13 113,85.87 113,84.4 112.48,83.87 112.48,81.14 102.87,71.53 96.49,71.53 92.91,67.95 92.91,62.34 91.65,61.07 87.59,61.07 86.39,62.28 84.93,62.28 v2(84.69,62.03)
  BOTTOM w0.127: v2(164.72,99.7) 164.35,100.07 U25.J6 ; v2(84.69,62.03) 84.44,62.28 83.32,62.28 83.05,62.55 82.6,62.55 R295.2
SATA_RXN1_NG: length 40.2
  TOP w0.127: v2(83.43,42.16) 83.14,42.46 83.14,43.63 82.32,44.44 82.32,47.42 81.56,48.18 81.56,52.06 79.02,54.6 79.02,60.1 v1(79.55,60.63) 79.02,61.16 79.02,61.65 79.93,62.56 80.76,62.56 R295.1
  BOTTOM w0.127: C779.1 95.14,37.65 94.97,37.82 94.97,38.88 94.15,39.7 88.26,39.7 87.15,40.82 83.43,40.82 83.14,41.11 83.14,41.87 v2(83.43,42.16)
SATA_RXN1_NG_C: length 16.5
  BOTTOM w0.127: C779.2 95.14,36.87 94.97,36.7 94.97,35.86 95.13,35.69 95.13,34.11 96.24,33.01 96.24,32.77 97.28,31.72 97.28,27.58 99.56,25.3 100.88,25.3 101.04,25.45 CN29.43
SATA_RXN1_SSD: length 9.8
  BOTTOM w0.127: C756.2 81.29,62.46 81.08,62.67 80.3,62.67 78.87,61.24 78.48,61.24 v1(77.96,60.72) 77.44,61.24 77.21,61.24 76.15,60.17 76.15,59.06 76.45,58.75 CN26.25
SATA_RXN2: length 54.1
  IN1 w0.076: v2(162.9,100.66) 162.9,100.81 162.61,101.1 162.61,101.4 162.44,101.56 162.44,102.81 162.8,103.17 162.8,103.46 162.75,103.51 162.75,103.53
  IN1 w0.14: v2(195.1,87.71) 194.74,88.06 194.74,89.99 194.63,90.1 194.63,95.21 193.13,96.71 193.13,100.09 192.53,100.69 192.53,101.85 189.43,104.95 180.71,104.95 179.68,103.92 167.96,103.92 167.05,104.83 163.6,104.83 162.75,103.97 162.75,103.53
  BOTTOM w0.076: U25.J8 163.26,100.29 v2(162.9,100.66)
  BOTTOM w0.127: C730.2 194.92,87.34 194.92,87.53 v2(195.1,87.71) 194.91,87.89 194.91,88.3 C728.2
SATA_RXN2_15: length 5.7
  TOP w0.127: v2(194.56,83.58) 194.27,83.87 193.58,83.87 193.26,83.55 ODD15.5
  BOTTOM w0.127: C730.1 195.08,85.86 195.08,85.66 195.17,85.57 195.39,85.57 195.82,85.14 195.82,84.62 195.03,83.83 194.82,83.83 v2(194.56,83.58)
SATA_RXN14_C: length 6.7
  BOTTOM w0.127: C728.1 195.02,89.49 194.92,89.59 194.92,89.89 195.02,89.99 195.95,89.99 v1(196.47,89.47) 196.48,89.47 197,89.99 198.02,89.99 198.47,90.45 199.26,90.45 199.8,89.91 ODD14.5
SATA_RXP0: length 97.6
  TOP w0.127: v2(196.49,40.13) 196.72,39.9 196.97,39.9 197.12,40.06 C793.2
  IN1 w0.14: v3(164.83,101.35) 165,101.18 165.5,101.18 166.23,101.91 167.41,101.91 168.51,103 180.17,103 180.91,103.75 184.49,103.75 184.74,103.49 187.49,103.49 188.03,104.04 189.05,104.04 191.62,101.47 191.62,100.2 192.21,99.61 192.21,93.87 193.18,92.89 193.68,92.4 193.68,90.33 193.18,89.83 193.18,83.37 194.14,82.41 194.14,81.42 196.1,79.46 196.1,77.51 195.67,77.09 195.67,72.14 197.6,70.22 197.6,58.12 197.93,57.79 197.93,49.5 195.9,47.48 195.9,42.16 195.73,41.99 195.73,40.05 195.9,39.88 196.24,39.88 196.29,39.93 v2(196.49,40.13)
  BOTTOM w0.127: U25.H5 165.23,100.94 v3(164.83,101.35)
SATA_RXP0_17: length 2.2
  TOP w0.127: HD17.6 199.15,39.75 199.02,39.61 198.84,39.61 198.54,39.92 198.29,39.92 C793.1
SATA_RXP1: length 110.7
  TOP w0.127: R292.2 82.58,62.79 83.08,62.79 83.36,62.51 84.4,62.51 v2(84.69,62.8)
  IN1 w0.14: v2(84.69,62.8) 84.94,62.54 86.5,62.54 87.7,61.34 91.54,61.34 92.65,62.45 92.65,68.06 96.38,71.79 102.76,71.79 112.22,81.25 112.22,83.99 112.74,84.51 112.74,85.98 120.15,93.4 121.41,93.4 122.05,94.04 123.75,94.04 125.73,96.01 133.57,96.01 134.7,94.88 143.75,94.88 144.47,94.16 150.29,94.16 151.83,95.69 154.64,95.69 155.27,96.32 156.17,96.32 157.11,97.26 160.79,97.26 162.45,98.92 162.87,99.33 163.69,99.33 v2(164.08,99.72)
  BOTTOM w0.127: v2(164.08,99.72) 163.98,99.82 163.98,100.38 164.36,100.76 U25.H6 ; v2(84.69,62.8) 84.4,62.51 83.41,62.51 83.15,62.78 82.6,62.78 R292.2
SATA_RXP1_NG: length 40.2
  TOP w0.127: R292.1 80.79,62.79 79.84,62.79 78.79,61.74 78.79,61.16 v1(78.26,60.63) 78.79,60.1 78.79,54.51 81.33,51.97 81.33,48.09 82.09,47.33 82.09,44.35 82.91,43.53 82.91,42.41 v2(82.67,42.16)
  BOTTOM w0.127: C778.1 94.74,37.88 94.74,38.79 94.05,39.47 88.17,39.47 87.05,40.59 83.34,40.59 82.91,41.02 82.91,41.92 v2(82.67,42.16)
SATA_RXP1_NG_C: length 16.5
  BOTTOM w0.127: C778.2 94.74,36.64 94.74,35.76 94.91,35.6 94.91,34.02 96.01,32.91 96.01,32.67 97.05,31.63 97.05,27.48 99.47,25.07 100.88,25.07 101,24.95 CN29.41
SATA_RXP1_SSD: length 9.8
  BOTTOM w0.127: C750.2 80.9,62.9 80.21,62.9 78.77,61.47 78.48,61.47 v1(77.96,61.99) 77.44,61.47 77.12,61.47 75.92,60.27 75.92,59.03 75.65,58.76 CN26.23
SATA_RXP2: length 53.9
  IN1 w0.076: 163.02,103.53 163.02,103.51 162.96,103.46 162.96,103.1 162.61,102.74 162.61,101.66 v3(163,101.27)
  IN1 w0.14: v2(194.33,87.71) 194.47,87.85 194.47,89.88 194.36,89.99 194.36,95.1 192.86,96.6 192.86,99.98 192.26,100.58 192.26,101.74 189.32,104.69 180.83,104.69 179.79,103.65 167.85,103.65 166.94,104.56 163.71,104.56 163.02,103.86 163.02,103.53
  BOTTOM w0.076: U25.H8 163.41,100.83 163.65,100.58 163.8,100.58 163.94,100.72 163.94,100.85 163.53,101.27 v3(163,101.27)
  BOTTOM w0.127: C729.2 194.68,87.26 194.68,87.36 v2(194.33,87.71) 194.68,88.06 194.68,88.34 C727.2
SATA_RXP2_15: length 5.7
  TOP w0.127: ODD15.6 193.43,84.05 193.49,84.1 194.49,84.1 194.59,84.2 v2(194.59,84.34)
  BOTTOM w0.127: C729.1 194.69,86.13 194.85,85.97 194.85,85.57 195.08,85.34 195.3,85.34 195.59,85.05 195.59,84.71 194.93,84.06 194.72,84.06 194.59,84.19 v2(194.59,84.34)
SATA_RXP14_C: length 6.8
  BOTTOM w0.127: C727.1 194.54,89.49 194.66,89.62 194.66,90 194.91,90.25 194.94,90.25 195.97,90.25 v1(196.47,90.74) 196.96,90.25 197.88,90.25 198.34,90.7 199.49,90.7 ODD14.6
SATA_TXN0: length 111.7
  TOP w0.127: v2(196.49,38.1) 196.75,37.85 196.94,37.85 197.12,38.02 C795.2
  IN1 w0.14: v2(158.98,107.09) 159.48,106.59 168.44,106.59 169.55,105.48 177.12,105.48 179.21,107.57 185.16,107.57 186.21,106.52 190.1,106.52 190.34,106.27 190.76,106.27 193.52,103.51 194.93,102.1 194.93,98.77 197.22,96.49 197.22,82.74 196.84,82.36 196.84,76.95 196.43,76.54 196.43,72.45 198.36,70.52 198.36,64.66 198.98,64.04 198.98,62.47 198.37,61.86 198.37,58.51 198.52,58.35 198.83,58.05 198.83,48.98 197.64,47.79 197.64,38.21 197.34,37.91 196.69,37.91 v2(196.49,38.1)
  BOTTOM w0.127: v2(158.98,107.09) 158.98,107.09 158.98,105.99 158.64,105.66 U25.B15
SATA_TXN0_17: length 2.1
  TOP w0.127: C795.1 198.28,37.9 198.47,37.9 198.68,38.11 199.02,38.11 199.15,38.25 HD17.3
SATA_TXN1: length 108.5
  TOP w0.127: v2(83.29,60.69) 83.05,60.45 82.52,60.45 82.07,60.9 R297.2
  IN1 w0.076: v2(159.48,104.24) 159.48,103.92 159.39,103.82 159.23,103.82 159.01,104.04 157.99,104.04 157.59,103.64 157.59,101.16 157.47,101.03 157.47,100.72 157.42,100.68 157.42,100.61
  IN1 w0.14: v2(83.29,60.69) 83.29,60.51 83.42,60.38 83.62,60.38 83.96,60.72 83.96,61.51 83.41,62.05 83.41,64.92 86.76,68.26 89.7,68.26 95.23,73.79 101.91,73.79 110.17,82.05 110.17,86.53 115.48,91.83 115.94,91.83 119.33,95.23 120.65,95.23 121.55,96.12 122.18,96.12 122.52,96.46 123.41,96.46 124.71,97.76 124.71,97.92 125.79,99 131.58,99 131.85,98.73 133.73,98.73 135.46,97 149.48,97 150.06,97.59 154.02,97.59 155.8,99.37 156.77,99.37 157.42,100.02 157.42,100.61
  BOTTOM w0.127: v2(159.48,104.24) 159.62,104.37 U25.B14 ; R297.2 82.07,60.9 82.52,60.45 83.05,60.45 v2(83.29,60.69)
SATA_TXN1_NG: length 37.1
  TOP w0.127: v2(84.78,41.82) 84.52,42.09 84.33,42.09 84.02,42.39 84.02,44 83.11,44.91 83.11,48.79 82.95,48.95 82.95,52.61 82.31,53.25 82.02,53.54 v1(81.28,53.54) 81.28,54.29 80.79,54.78 79.68,55.89 79.68,59.64 80.52,60.48 80.76,60.48 R297.1
  BOTTOM w0.127: v2(84.78,41.82) 85.05,42.09 87.84,42.09 89.59,40.34 94.76,40.34 96.9,38.19 96.9,37.88 C780.1
SATA_TXN1_NG_C: length 13.9
  BOTTOM w0.127: CN29.47 100.98,26.45 100.86,26.57 99.87,26.57 98.6,27.84 98.6,31.2 98.07,31.73 98.07,34.78 96.9,35.95 96.9,36.64 C780.2
SATA_TXN1_SSD: length 5.9
  BOTTOM w0.127: C757.2 81.29,60.7 81.13,60.53 80.64,60.53 v1(80.17,61) 79.65,60.48 79.25,60.48 78.85,60.08 CN26.31
SATA_TXN2: length 65
  IN1 w0.14: v2(194.8,82.86) 194.8,82.77 195.08,82.49 195.57,82.49 196.23,83.14 196.23,96.08 193.79,98.52 193.79,101.53 189.72,105.6 180.45,105.6 179.41,104.57 169.17,104.57 168.17,105.58 162.15,105.58 161.83,105.26 160.54,105.26 160.38,105.42 159.32,105.42 158.99,105.75 158.99,106.16 158.84,106.31 158.6,106.31 158.46,106.18 v2(158.46,106.07)
  BOTTOM w0.127: U25.A17 158.29,105.51 158.41,105.39 158.41,105.09 158.32,105 158.19,105 157.86,105.33 157.86,105.79 158.24,106.17 158.36,106.17 v2(158.46,106.07) ; C732.2 195.59,82.74 195.34,82.49 195.17,82.49 v2(194.8,82.86) 194.8,82.74 194.5,82.44 194.32,82.44 194.11,82.64 C731.2
SATA_TXN2_15: length 3.1
  TOP w0.127: ODD15.3 192.38,82.55 192.24,82.41 192.07,82.41 v2(191.81,82.68)
  BOTTOM w0.127: v2(191.81,82.68) 192.07,82.41 193.21,82.41 193.33,82.54 C731.1
SATA_TXN14_C: length 7.4
  BOTTOM w0.127: C732.1 196.74,82.44 197.6,82.44 198.14,82.98 198.14,86.14 198.69,86.68 199.28,86.68 ODD14.3
SATA_TXP0: length 111.8
  TOP w0.127: v2(196.49,37.47) 196.65,37.62 196.98,37.62 197.12,37.47 C796.2
  IN1 w0.14: v3(159.74,107.09) 159.98,106.86 168.55,106.86 169.66,105.75 177.01,105.75 179.1,107.84 185.27,107.84 186.32,106.78 190.21,106.78 190.45,106.54 190.87,106.54 195.2,102.21 195.2,98.88 197.48,96.6 197.48,82.63 197.11,82.25 197.11,76.84 196.7,76.43 196.7,72.59 198.63,70.66 198.63,64.77 199.25,64.15 199.25,62.36 198.63,61.75 198.63,58.62 199.09,58.16 199.09,57.94 199.09,48.87 197.91,47.68 197.91,38.1 197.45,37.64 196.67,37.64 v2(196.49,37.47)
  BOTTOM w0.127: U25.A15 158.97,105.44 159.09,105.32 159.27,105.32 159.38,105.44 159.38,105.72 159.21,105.89 159.21,106.56 v3(159.74,107.09)
SATA_TXP0_17: length 2.1
  TOP w0.127: C796.1 198.3,37.67 198.56,37.67 198.78,37.89 199.02,37.89 199.15,37.75 HD17.2
SATA_TXP1: length 108.6
  TOP w0.127: v2(83.29,59.93) 83,60.22 82.42,60.22 82.07,59.88 R300.2
  IN1 w0.076: 157.69,100.61 157.69,100.68 157.63,100.74 157.63,100.97 157.76,101.09 157.76,103.58 158.05,103.87 158.95,103.87 159.15,103.67 v2(159.15,103.3)
  IN1 w0.14: 157.69,100.61 157.69,99.9 156.88,99.1 155.91,99.1 154.13,97.32 150.17,97.32 149.59,96.74 135.35,96.74 133.62,98.46 131.74,98.46 131.47,98.73 125.91,98.73 124.98,97.81 124.98,97.65 123.52,96.19 122.63,96.19 122.29,95.85 121.66,95.85 121.29,95.48 120.76,94.96 119.44,94.96 116.05,91.57 115.59,91.57 110.44,86.42 110.44,81.94 102.02,73.52 95.34,73.52 89.81,68 86.87,68 83.68,64.81 83.68,62.16 84.22,61.62 84.22,60.6 83.73,60.11 83.47,60.11 v2(83.29,59.93)
  BOTTOM w0.127: R300.2 82.07,59.88 82.42,60.22 83,60.22 v2(83.29,59.93) ; v2(159.15,103.3) 158.98,103.47 U25.C15
SATA_TXP1_NG: length 37.1
  TOP w0.127: v2(84.78,42.58) 84.52,42.32 84.42,42.32 84.25,42.49 84.25,44.09 83.34,45 83.34,48.89 83.18,49.04 83.18,52.71 82.19,53.7 v1(82.19,54.43) 81.46,54.43 80.95,54.94 79.96,55.93 79.91,55.98 79.91,59.54 80.61,60.25 80.79,60.25 R300.1
  BOTTOM w0.127: C782.1 97.27,37.65 97.13,37.8 97.13,38.29 94.85,40.56 89.69,40.56 87.93,42.32 85.05,42.32 v2(84.78,42.58)
SATA_TXP1_NG_C: length 13.9
  BOTTOM w0.127: CN29.49 100.91,26.95 100.75,26.8 99.97,26.8 98.83,27.93 98.83,31.29 98.3,31.83 98.3,34.87 97.13,36.04 97.13,36.7 97.3,36.87 C782.2
SATA_TXP1_SSD: length 5.9
  BOTTOM w0.127: CN26.33 79.65,58.68 79.08,59.25 79.08,59.99 79.34,60.25 79.65,60.25 v1(80.17,59.73) 80.74,60.3 81.18,60.3 81.29,60.18 C759.2
SATA_TXP2: length 64.9
  IN1 w0.14: v3(158.46,106.71) 158.59,106.58 158.95,106.58 159.26,106.27 159.26,105.86 159.43,105.69 160.49,105.69 160.65,105.52 161.72,105.52 162.04,105.84 168.28,105.84 169.28,104.83 179.3,104.83 180.34,105.87 189.83,105.87 194.05,101.64 194.05,98.63 196.49,96.19 196.49,83.03 195.68,82.22 194.93,82.22 v2(194.8,82.1)
  BOTTOM w0.127: v3(158.46,106.71) 157.63,105.89 157.63,105.23 157.87,105 U25.B17 ; C733.2 194.11,81.86 194.46,82.2 194.7,82.2 v2(194.8,82.1) 195.34,82.1 195.59,81.84 C734.2
SATA_TXP2_15: length 3.1
  TOP w0.127: v2(191.81,81.92) 192.07,82.19 192.23,82.19 192.37,82.05 ODD15.2
  BOTTOM w0.127: v2(191.81,81.92) 192.07,82.19 193.2,82.19 193.33,82.05 C733.1
SATA_TXP14_C: length 7.4
  BOTTOM w0.127: C734.1 196.77,82.18 197.7,82.18 198.4,82.88 198.4,86.03 198.79,86.42 199.31,86.42 ODD14.2
SCLK: length 5.8
  TOP w0.127: PR79.1 100.47,85.65 100.22,85.9 98.95,85.9 PR78.2 97.74,85.4 96.74,84.4 PU3.5
SD_CD#: length 50.5
  TOP w0.127: v2(31.39,21.77) 30.69,22.47 30.69,32.12 33.22,34.65 CN15.11 ; U19.30 v2(62.98,14.87)
  BOTTOM w0.127: v2(31.39,21.77) 32.61,20.55 38.4,20.55 38.96,19.99 56.84,19.99 v1(58.19,18.64) 61.97,14.87 v2(62.98,14.87)
SD_CLK_R: length 4.6
  TOP w0.127: U19.17 59.76,19.61 58.75,20.63 R390.1 58.01,20.63 57.57,20.18 56.34,20.18 v2(56.29,20.23)
SD_CMD_R: length 4.9
  TOP w0.127: v2(56.07,18.03) 56.34,18.03 56.35,18.02 56.72,18.02 56.74,18.03 57.51,18.03 R396.1 58.46,18.2 58.87,18.2 59.48,18.81 U19.19
SD_D0_R: length 5.6
  TOP w0.127: U19.16 60.98,20.7 60.81,20.88 59.38,20.88 58.5,21.76 R377.1 58.19,21.81 57.71,22.29 v2(57.71,23.59)
SD_D1: length 47.4
  TOP w0.127: CN15.8 34.82,31.55 EC41.1 33.49,30.4 v2(33.46,30.43) ; R378.2 59.21,22.91 v2(58.95,23.17)
  BOTTOM w0.127: v2(58.95,23.17) 59.05,23.27 59.05,24.1 58.72,24.44 57.61,24.44 56.21,25.83 51.1,25.83 47.62,29.31 46.25,29.31 46.12,29.18 46.12,28.88 45.98,28.73 45.77,28.73 45.62,28.88 45.62,29.18 45.49,29.31 45.24,29.31 45.11,29.18 45.11,28.14 44.98,28.02 44.73,28.02 44.6,28.14 44.6,29.18 44.47,29.31 44.12,29.31 43.99,29.18 43.99,28.14 43.86,28.02 43.61,28.02 43.48,28.14 43.48,29.18 43.36,29.31 43.1,29.31 42.98,29.18 42.98,28.14 42.85,28.02 42.59,28.02 42.47,28.14 42.47,29.18 42.34,29.31 42.09,29.31 41.96,29.18 41.96,28.14 41.83,28.02 41.58,28.02 41.45,28.14 41.45,29.18 41.32,29.31 40.97,29.31 40.84,29.18 40.84,28.14 40.71,28.02 40.46,28.02 40.33,28.14 40.33,29.18 40.21,29.31 34.58,29.31 v1(33.98,29.91) v2(33.46,30.43)
SD_D1_R: length 3.1
  TOP w0.127: R378.1 60.06,21.76 v2(60.07,21.75) 60.58,21.23 60.98,21.23 61.38,20.84 U19.15
SD_D2_R: length 4.3
  TOP w0.127: U19.21 59.74,18.01 59.54,17.81 59.54,17.02 59.08,16.56 R402.1 58.07,15.55 v1(58.06,15.55)
SD_D3_R: length 2.6
  TOP w0.127: R398.1 58.77,17.58 59.61,18.41 U19.20
SDIO: length 5.4
  TOP w0.127: PR84.1 100.47,83.24 100.09,82.86 98.95,82.86 PR83.2 97.92,83.36 97.69,83.6 PU3.3
SDIO_CLK: length 18.3
  TOP w0.127: v3(166.91,102.41) 168.05,102.41 169.42,103.78 171.3,103.78 172.2,104.69 176.04,104.69 176.05,104.7 176.37,104.7 179.75,108.08 179.75,108.31 180.34,108.89 180.92,108.89 181.18,108.64 181.18,108.09 RP2.4
  BOTTOM w0.076: v3(166.91,102.41) 166.61,102.71 U25.E3
SDIO_CMD: length 19.8
  TOP w0.127: v2(166.26,102.41) 166.77,102.92 167.28,102.92 v1(167.79,103.43) 168.4,104.04 171.19,104.04 172.1,104.94 175.93,104.94 175.94,104.95 176.27,104.95 179.5,108.19 179.5,108.51 180.16,109.17 181.23,109.17 181.81,108.59 RP2.3
  BOTTOM w0.076: U25.F4 166.26,102.3 v2(166.26,102.41)
SDIO_D1: length 20.8
  TOP w0.127: v3(165.86,103.35) 166.32,103.35 167.26,104.29 171.07,104.29 171.98,105.21 176.16,105.21 179.25,108.29 179.25,108.61 180.06,109.42 181.75,109.42 182.45,108.72 RP2.2
  BOTTOM w0.076: v3(165.86,103.35) 165.96,103.25 U25.E4
