# Allegro board 大･ｬ Quanta day34gmb6b0-b-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_WE#: length 64.2
  IN1 w0.076: v2(146.76,88.92) 147.18,88.51 147.18,85.82 147.2,85.8 147.2,85.29 146.56,84.64 146.56,78.56 147.23,77.89 147.23,76.11 147.95,75.39 147.95,74.55 147.85,74.45
  IN1 w0.216: v4(149.12,44.55) 149.12,50.17 149.33,50.37 149.84,50.37 150.03,50.56 150.03,50.83 149.84,51.02 149.31,51.02 149.12,51.21 149.12,51.47 149.31,51.66 149.84,51.66 150.03,51.85 150.03,52.12 149.84,52.31 149.38,52.31 149.19,52.5 149.19,52.77 149.38,52.96 149.67,52.96 149.86,53.15 149.86,53.44 151.11,54.68 152.28,55.86 152.28,60.22 151.99,60.52 150.57,60.52 150.38,60.71 150.38,60.98 150.57,61.17 152.09,61.17 152.28,61.36 152.28,61.63 152.09,61.81 150.57,61.81 150.38,62 150.38,62.27 150.57,62.46 150.89,62.46 151.08,62.65 151.08,62.92 150.89,63.11 150.57,63.11 150.38,63.3 150.38,64.28 149.89,64.77 149.89,65.26 147.41,67.74 147.41,74.01 147.85,74.45
  BOTTOM w0.076: v2(146.76,88.92) 146.86,89.03 146.96,89.03 U25.AK35
  BOTTOM w0.191: JDIM1.113 148.35,43.17 148.58,42.94 148.78,42.94 149.12,43.28 v4(149.12,44.55)
MAINON: length 279.3
  TOP w0.127: PR124.2 61.24,34.46 v1(61.24,36.5) 60.86,36.88 60.86,42.84 63.16,45.14 v2(64.41,45.14) 62.87,43.6 PR113.2 ; v2(39.26,68.12) 39.26,66.46 38.4,65.6 U11.33 ; v2(82.21,28.32) 85.51,31.62 92.78,31.62 93.27,31.14 94.92,31.14 v2(95.5,31.14) 95.55,31.19 95.55,32.03 93.8,33.78 PR129.1 ; R274.2 27.33,73.21 v2(27.33,73.97) ; v2(193.19,62.15) 193.06,62.28 PR106.2
  IN1 w0.14: v2(38,73.76) 37.18,72.95 30.42,72.95 29.4,73.97 v2(27.33,73.97)
  IN2 w0.14: v2(193.19,62.15) 189.46,58.42 189.46,55.53 187.98,54.05 187.45,54.05 186.75,53.35 186.29,53.35 184.56,51.62 184.56,49.55 187.53,46.58 187.53,42.65 186.59,41.71 186.59,34.91 184.63,32.96 183.49,32.96 182.36,31.83 182.36,28.23 180.41,26.29 180.41,26 174.55,20.14 174.31,20.14 170.16,15.99 167.68,15.99 166.16,14.47 162.78,14.47 161.77,15.48 159.49,15.48 158.61,16.37 150.76,16.37 150.33,16.81 121,16.81 120.27,16.08 118.26,16.08 117.53,16.81 111.57,16.81 109.53,14.77 105.04,14.77 99.26,20.55 99.26,27.38 v2(95.5,31.14) ; v2(82.21,28.32) 82.21,28.61 69.02,41.8 69.02,42.11 66,45.14 v2(64.41,45.14) 63.2,45.14 61.46,46.87 61.46,48.62 54.42,55.66 52.94,55.66 49.08,59.52 47.49,61.12 47.26,61.12 46.63,61.75 44.63,61.75 41.72,64.66 41.72,65.54 39.26,68 v2(39.26,68.12) 39.26,68.26 37.15,70.37 37.15,72.91 v2(38,73.76)
  BOTTOM w0.127: PR169.1 198.78,64.43 198.78,63.48 197.28,61.98 193.36,61.98 v2(193.19,62.15)
MBATLED0#: length 43
  TOP w0.127: v2(36.37,98.3) 37.46,98.3 37.9,98.73 PQ14.2 37.9,99.9 38.63,100.64 v1(39.27,100.64) 39.77,100.64 40.56,99.85 40.56,98.65 40.38,98.48 39.65,98.48 39.24,98.07 PQ12.2 ; v2(35.4,68.37) 35.57,68.53 U11.25
  BOTTOM w0.127: v2(36.37,98.3) 36.4,98.27 36.4,94.49 34.64,92.73 34.64,83.04 36.44,81.23 36.44,69.2 35.61,68.37 v2(35.4,68.37)
MBCLK: length 209.3
  TOP w0.127: v2(119.76,184.89) 119.76,182.68 120.37,182.08 PD2.1 121.96,182.08 122.32,182.43 122.32,184.83 v1(122.32,184.84) 122.77,185.28 126.83,185.28 127.03,185.48 PC11.1 PR2.2 ; v2(49.81,93.14) 49.81,92.71 50.82,91.69 50.82,90.58 49.7,89.45 R190.2 48.05,89.45 45.72,87.12 45.72,80.9 45.6,80.78 U11.110 ; PR15.2 84.47,173.8 80.17,173.8 v2(79.96,174.02)
  IN1 w0.14: v2(81.41,165.79) 81.89,166.27 81.89,169.85 79.96,171.78 v2(79.96,174.02) 79.96,174.65 83.31,178 84.07,178 86.54,180.47 86.54,182.18 88.76,184.4 94.43,184.4 94.83,184.01 97.53,184.01 98.37,184.85 101.29,184.85 101.7,185.27 107.19,185.27 109.62,182.83 117.7,182.83 v2(119.76,184.89)
  BOTTOM w0.14: v2(81.41,165.79) 80.92,165.3 80.92,160.56 76.63,156.26 50.69,156.26 34.72,140.29 34.72,116.71 37.02,114.41 37.02,111.97 37.45,111.54 37.45,110.26 49.38,98.33 49.38,93.57 v2(49.81,93.14)
MBCLK2: length 292.8
  TOP w0.127: v2(48.52,65.24) 48.39,65.36 48.39,66.7 46.79,68.31 46.79,72.51 46.18,73.12 46.18,76.14 43.71,78.61 43.71,78.89 43.6,79 U11.115 43.6,80.55 43.11,81.04 43.11,82.21 43.74,82.84 43.74,84.09 40.02,87.81 R197.2 ; U16.8 117.07,23.25 115.95,22.13 115.95,20.14 v1(116.86,19.23) v2(118.77,17.32) ; v2(84.3,28.6) 84.38,28.52 84.89,28.52 84.99,28.63 88.03,28.63 88.92,27.74 90.45,27.74 90.7,27.99 92.48,27.99 96.16,24.31 96.16,23.27 100.86,18.57 100.86,16.51 v2(100.71,16.36)
  IN1 w0.14: v2(100.71,16.36) 101.19,16.36 102.31,15.24 108.75,15.24 110.93,17.42 118.67,17.42 v2(118.77,17.32) 119.21,16.88 136.38,16.88 137.45,17.95 159.78,17.95 160.01,17.71 165.05,17.71 165.49,17.27 166.19,17.27 166.49,16.97 169.58,16.97 171.79,19.18 176.26,19.18 183.57,26.49 185.3,28.22 185.3,30.77 185.68,31.15 185.68,33.84 186.34,34.5 186.34,42.51 188.41,44.57 188.41,50.83 191.74,54.16 191.74,57.24 191.34,57.64 191.34,58.53 188.29,61.58 188.29,64.14 188.28,64.14 188.28,64.59 187.63,65.25 186.25,65.25 184.21,67.29 184.21,76.26 182.43,78.04 182.43,82.34 181.17,83.6 181.17,85.08 180.91,85.34 180.9,85.34 180.29,85.95 180.14,85.95 179.18,86.91 179.18,87.42 179.17,87.42 179.17,87.6 178.26,88.52 178.26,90.4 181.53,93.67 181.53,94.03 183.21,95.71 188.01,95.71 188.36,96.06 188.36,96.62 187.66,97.33 v2(187.15,97.33)
  IN2 w0.14: v2(84.3,28.6) 83.46,29.44 82.5,29.44 69.81,42.13 69.81,42.62 65.6,46.83 64,46.83 63.15,47.68 63.15,48.55 53.55,58.14 53.55,58.46 51.29,60.72 51.29,60.73 50.65,61.37 50.65,63.17 48.58,65.24 v2(48.52,65.24)
  BOTTOM w0.127: v2(187.15,97.33) 187.15,97.61 186.72,98.03 Q38.4
MBCLK3: length 223.1
  TOP w0.127: U13.4 186.88,55.85 186.33,55.3 185.96,55.3 185.58,54.92 C387.1 v2(186.21,54.66) R299.1 ; U11.94 53.68,77.33 54.02,77.67 54.02,79.3 54.25,79.53 v1(56.79,79.53) 57.95,79.53 60.93,82.5 64.35,82.5 64.68,82.83 v2(64.68,83.54) ; v2(108.28,16.1) 107.64,15.47 104.87,15.47 98.25,22.1 98.25,26.42 v2(98.7,26.87)
  IN2 w0.14: v2(64.68,83.54) 64.79,83.43 64.79,79.48 64.41,79.1 64.41,73.81 64.72,73.5 64.72,72.06 64.49,71.83 64.49,69.01 64.72,68.78 64.72,62.76 72.99,54.5 74.94,54.5 76.48,52.96 76.48,52.35 76.48,50.04 82.65,43.87 84.99,43.87 86.13,42.72 86.13,39.07 89.1,36.09 90.53,36.09 91.02,35.61 91.5,35.61 91.51,35.61 91.51,35.61 92.04,35.09 92.04,34.63 94.15,32.52 94.15,31.69 98.58,27.26 98.58,27 v2(98.7,26.87) ; v2(186.21,54.66) 185.75,54.66 183.25,52.17 183.25,47.11 183.89,46.48 183.89,40.59 185.28,39.21 185.28,36.29 184.09,35.11 183.69,35.11 181.05,32.46 181.05,28.77 179.11,26.83 179.11,26.54 174.27,21.71 174.03,21.71 169.62,17.3 166.88,17.3 165.36,15.78 163.33,15.78 162.31,16.79 160.03,16.79 159.09,17.74 154.92,17.74 154.54,18.12 110.29,18.12 v2(108.28,16.1)
MBDATA: length 200.8
  TOP w0.127: v2(49.93,93.8) 49.5,93.8 49.2,93.5 49.2,92.62 R182.2 49.05,92.39 48.54,91.87 48.54,90.51 45.32,87.29 45.32,81.04 45.2,80.92 U11.111 ; PC10.1 PR1.2 122.58,186.74 v1(122.32,186.49) 121.69,185.85 121.69,184.72 PD1.1 120.77,184.11 120.53,184.34 120.53,184.71 v2(120.7,184.89) ; PR13.2 85.82,175.51 84.36,174.05 80.83,174.05 v2(80.49,174.4)
  IN1 w0.14: v2(81.41,165.07) 82.27,165.94 82.27,170.1 80.49,171.88 v2(80.49,174.4) 80.49,174.7 83.53,177.74 84.18,177.74 86.82,180.37 86.82,182.08 88.87,184.14 94.32,184.14 94.71,183.74 97.64,183.74 98.48,184.59 101.4,184.59 101.77,184.96 107.01,184.96 109.55,182.42 118.24,182.42 v2(120.7,184.89)
  BOTTOM w0.14: v2(81.41,165.07) 81.41,160.48 76.81,155.88 50.87,155.88 35.13,140.14 35.13,116.87 37.43,114.57 37.43,112.13 37.88,111.67 37.88,110.39 49.77,98.5 49.77,93.97 v2(49.93,93.8)
MBDATA2: length 285.2
  TOP w0.127: v2(119.78,17.35) v1(118.41,18.72) 116.46,20.68 116.46,21.92 117.14,22.6 U16.7 ; v2(100.02,16.79) 100.02,18.8 95.53,23.29 95.53,24.18 92.48,27.23 91.72,27.23 91.46,26.98 88.92,26.98 87.86,28.04 83.64,28.04 83.4,27.8 v2(83.37,27.8) ; v2(47.86,65.24) 48.01,65.38 48.01,66.37 46.4,67.97 46.4,72.17 45.67,72.91 45.67,75.93 43.2,78.4 U11.116 43.2,80.62 42.88,80.94 42.88,82.3 43.23,82.65 43.23,83.88 40.32,86.79 R203.2
  IN1 w0.14: v2(100.02,16.79) 100.1,16.87 101.78,16.87 103.01,15.63 108.59,15.63 110.76,17.81 119.32,17.81 v2(119.78,17.35) 119.79,17.34 135.86,17.34 136.85,18.34 159.94,18.34 160.18,18.1 165.21,18.1 165.65,17.66 166.35,17.66 166.65,17.36 169.41,17.36 171.76,19.7 176.23,19.7 183.41,26.89 183.95,27.43 183.95,29.98 185.28,31.32 185.28,34 185.95,34.67 185.95,42.85 187.89,44.79 187.89,51.07 190.97,54.15 190.97,56.5 190.4,57.07 190.4,58.74 187.76,61.37 187.76,64.38 187.28,64.86 186.09,64.86 183.82,67.13 183.82,76.1 182.03,77.88 182.03,82.18 180.19,84.03 180.19,85.14 178.78,86.55 178.78,87.25 177.82,88.21 177.82,93.27 179.28,94.73 181.57,94.73 182.49,95.64 v2(182.49,96.19)
  IN2 w0.14: v2(83.37,27.8) 83.37,28.01 69.42,41.96 69.42,42.46 65.44,46.44 64.09,46.44 63.66,46.44 62.56,47.53 62.56,48.26 54.66,56.16 53.85,56.16 53.16,56.85 53.16,58.29 50.89,60.56 50.89,60.56 50.63,60.83 50.63,60.83 50.19,61.27 50.19,63.07 49.09,64.17 48.93,64.17 v2(47.86,65.24)
  BOTTOM w0.127: v2(182.49,96.19) 183.03,96.73 Q38.1
MBDATA3: length 224.9
  TOP w0.127: U11.95 53.27,77.73 53.52,77.98 53.52,79.53 54.05,80.06 v1(54.63,80.06) 57.77,80.06 60.74,83.03 v2(64.16,83.03) ; U13.6 188.02,56.9 C394.1 R301.1 188.75,54.66 188.24,55.17 v2(188.24,55.42) ; v2(98.7,24.31) 98.91,24.1 98.91,22.23 105.03,16.1 v2(106.83,16.1)
  IN2 w0.14: v2(106.83,16.1) 107.19,16.1 107.71,15.58 108.06,15.58 108.61,15.58 110.62,17.6 117.86,17.6 118.58,16.87 119.95,16.87 120.67,17.6 154.32,17.6 154.7,17.22 158.88,17.22 159.82,16.27 162.1,16.27 163.11,15.26 165.57,15.26 167.09,16.78 169.84,16.78 173.98,20.92 174.22,20.92 179.63,26.33 179.63,26.62 181.57,28.56 181.57,32.25 181.85,32.52 181.85,32.53 183.91,34.59 184.42,34.59 185.8,35.97 185.8,39.45 184.41,40.83 184.41,48.51 183.77,49.15 183.77,51.95 185.96,54.14 186.42,54.14 187.12,54.84 187.65,54.84 v2(188.24,55.42) ; v2(98.7,24.31) 98.14,24.87 98.14,26.7 98.05,26.78 98.05,27.04 93.63,31.47 93.63,32.3 91.51,34.41 91.51,34.87 91.3,35.09 90.8,35.09 90.33,35.56 88.87,35.56 85.49,38.94 85.49,42.6 84.75,43.34 82.43,43.34 75.95,49.82 75.95,52.57 74.55,53.98 72.77,53.98 63.48,63.27 63.48,70.7 62.73,71.45 62.73,81.52 64.15,82.94 64.15,83.03 v2(64.16,83.03)
MDI0+: length 52
  TOP w0.127: U8.1 25.7,115.62 26.66,114.67 27.93,114.67 v2(28.09,114.5) ; U6.11 28,157.15 v2(28.09,157.06)
  IN1 w0.14: v2(28.09,157.06) 28.27,156.88 28.74,156.88 29.49,156.13 29.49,155.12 32.15,152.45 32.15,121.01 30.36,119.22 30.36,115.51 29.36,114.5 v2(28.09,114.5)
MDI0+_1: length 24.1
  TOP w0.127: U6.6 16.5,157.15 v2(16.46,157.19)
  IN1 w0.14: CN21.1 16.88,172.27 18.31,170.84 18.31,161.24 16.75,159.68 16.26,159.68 15.68,159.09 15.68,156.16 15.98,155.85 16.76,155.85 17.04,156.13 17.04,156.61 v2(16.46,157.19)
MDI0-: length 52
  TOP w0.127: v2(28.09,154.77) 27.93,154.61 U6.9 ; U8.2 25.92,116.02 26.84,115.1 27.93,115.1 v2(28.09,115.26)
  IN1 w0.14: v2(28.09,154.77) 27.91,154.95 27.91,156.11 28.16,156.36 28.53,156.36 28.97,155.92 28.97,154.9 31.63,152.24 31.63,121.22 29.84,119.43 29.84,115.72 29.14,115.02 28.33,115.02 v2(28.09,115.26)
MDI0-_1: length 24.1
  TOP w0.127: v2(16.45,154.65) 16.49,154.61 U6.8
  IN1 w0.14: CN21.2 16.1,171.25 16.18,171.32 16.18,171.57 16.36,171.75 16.67,171.75 17.79,170.62 17.79,161.45 16.54,160.2 16.05,160.2 15.16,159.3 15.16,155.94 15.76,155.33 16.19,155.33 16.45,155.08 v2(16.45,154.65)
MDI1+: length 64.3
  TOP w0.127: U6.16 28,163.5 v2(28.09,163.41) ; U8.4 26.47,116.82 27.33,117.68 28.9,117.68 30.17,116.41 30.85,116.41 v2(31.01,116.24)
  IN1 w0.14: v2(31.01,116.24) 31.68,116.24 32.13,116.69 32.13,117.98 33.32,119.18 33.32,153.06 30.88,155.5 30.88,158.29 30.12,159.06 29.44,159.06 29.23,159.26 29.23,159.87 29.44,160.07 30,160.07 31.09,161.16 31.09,163.79 30.58,164.3 29.61,164.3 29.11,163.79 29.11,163.54 28.98,163.41 v2(28.09,163.41)
MDI1+_1: length 11.8
  TOP w0.127: U6.1 16.99,163.5 16.49,163 v2(16.49,162.87)
  IN1 w0.14: v2(16.49,162.87) 16.49,162.76 16.21,162.48 15.88,162.48 15.68,162.69 15.68,164.04 17.14,165.51 17.14,167.63 16.57,168.2 16.57,168.26 15.22,169.61 CN21.3
MDI1-: length 64.3
  TOP w0.127: U8.5 25.52,117.22 25.55,117.25 26.29,117.25 27.15,118.11 29.08,118.11 30.35,116.84 30.85,116.84 v2(31.01,117) ; v2(28.09,161.09) 27.96,160.96 U6.14
  IN1 w0.14: v2(31.01,117) 31.25,116.76 31.47,116.76 31.61,116.9 31.61,118.2 32.8,119.39 32.8,152.84 30.36,155.28 30.36,158.08 29.91,158.53 29.22,158.53 28.71,159.04 28.71,160.08 29.22,160.59 29.78,160.59 30.57,161.38 30.57,163.58 30.36,163.78 29.83,163.78 29.63,163.58 29.63,163.32 29.2,162.89 28.45,162.89 28.09,162.53 v2(28.09,161.09)
MDI1-_1: length 11.8
  TOP w0.127: U6.3 16.92,160.96 v2(16.44,161.44)
  IN1 w0.14: CN21.6 15.53,167.17 16.1,167.74 16.29,167.74 16.62,167.41 16.62,165.72 15.16,164.26 15.16,162.47 15.66,161.96 15.91,161.96 v2(16.44,161.44)
MDI2+: length 26.1
  TOP w0.127: v2(29.83,120.41) 29.67,120.25 29.67,119.53 28.88,118.75 27.13,118.75 25.97,117.59 25.58,117.59 25.55,117.62 U8.6 ; U7.11 v2(27.96,136.19)
  IN1 w0.14: v2(27.96,136.19) 28.32,135.83 29.12,135.83 29.63,135.32 29.63,124.78 28.46,123.61 28.46,121.78 28.88,121.36 29.28,121.36 29.72,120.93 29.72,120.53 v2(29.83,120.41)
MDI2+_1: length 44.3
  TOP w0.127: R124.2 18.63,149.71 18.24,149.71 18.11,149.83 18.11,150.1 v2(18.27,150.26) ; U7.6 v2(16.44,136.19)
  IN1 w0.14: v2(16.44,136.19) 16.44,135.79 16.23,135.59 15.88,135.59 15.68,135.79 15.68,146.84 18.15,149.31 18.15,150.13 v2(18.27,150.26)
  BOTTOM w0.127: v2(18.27,150.26) 18.11,150.43 18.11,151.03 19.25,152.17 19.25,167.64 v1(17.8,169.09) 17.8,168.66 17.58,168.43 16.92,168.43 16.26,169.09 14.24,169.09 CN21.4
MDI2-: length 26
  TOP w0.127: v2(29.07,120.41) 29.23,120.25 29.23,119.71 28.7,119.18 26.95,119.18 25.79,118.02 U8.7 ; U7.9 v2(27.96,133.65)
  IN1 w0.14: v2(29.07,120.41) 29.2,120.54 29.2,120.71 29.07,120.84 28.66,120.84 27.94,121.56 27.94,123.83 29.11,124.99 29.11,135.1 28.9,135.31 28.04,135.31 27.81,135.08 27.81,133.79 v2(27.96,133.65)
MDI2-_1: length 44.4
  TOP w0.127: v2(16.43,133.65) U7.8 ; v2(17.51,150.26) 17.68,150.1 17.68,149.65 18.06,149.28 18.63,149.28 R125.2
  IN1 w0.14: v2(16.43,133.65) 16.43,134.86 16.23,135.06 15.66,135.06 15.16,135.57 15.16,147.06 17.63,149.53 17.63,150.12 17.51,150.24 v2(17.51,150.26)
  BOTTOM w0.127: v2(17.51,150.26) 17.68,150.42 17.68,151.21 18.82,152.35 18.82,167.46 18.26,168.02 18.01,168.02 v1(17.8,167.82) 17.63,168 16.74,168 16.08,168.66 15.69,168.66 CN21.5
MDI3+: length 34.5
  TOP w0.127: U8.9 24.28,119.51 24.46,119.69 26.12,119.69 28.63,122.2 29.04,122.2 v2(29.21,122.03) ; U7.16 v2(27.96,142.54)
  IN1 w0.14: v2(27.96,142.54) 27.96,142.24 28.17,142.04 30.25,142.04 30.9,141.39 30.9,139.23 30.39,138.72 29.46,138.72 29.26,138.52 29.26,137.68 29.46,137.48 30.39,137.48 30.9,136.97 30.9,122.77 30.28,122.16 29.33,122.16 v2(29.21,122.03)
MDI3+_1: length 35.7
  TOP w0.127: U7.1 v2(16.46,142.54) ; v2(18.27,147.64) 18.43,147.47 18.61,147.47 R127.2
  IN1 w0.14: v2(18.27,147.64) 18.15,147.52 17.7,147.52 16.77,146.6 16.77,144.34 17.19,143.92 17.19,141.48 16.99,141.28 16.66,141.28 16.46,141.48 v2(16.46,142.54)
  BOTTOM w0.127: v2(18.27,147.64) 18.1,147.47 16.69,147.47 16.15,148.01 16.15,151.28 18.08,153.21 18.08,164.95 17.63,165.41 17.17,165.41 v1(16.79,165.79) 16.28,165.28 15.47,165.28 15.22,165.53 CN21.7
MDI3-: length 34.5
  TOP w0.127: U8.10 23.88,119.72 24.28,120.12 25.94,120.12 28.45,122.63 29.04,122.63 v2(29.21,122.8) ; U7.14 v2(27.96,140)
  IN1 w0.14: v2(29.21,122.8) 29.33,122.68 30.07,122.68 30.38,122.99 30.38,136.75 30.17,136.96 29.25,136.96 28.74,137.47 28.74,138.74 29.25,139.24 30.17,139.24 30.38,139.45 30.38,141.17 30.03,141.52 28.17,141.52 27.96,141.31 v2(27.96,140)
MDI3-_1: length 35.7
  TOP w0.127: R128.2 18.66,147.04 18.43,147.04 v2(18.27,146.88) ; v2(16.46,139.99) 16.47,140 U7.3
  IN1 w0.14: v2(16.46,139.99) 16.46,140.55 16.66,140.75 17.21,140.75 17.71,141.26 17.71,144.13 17.3,144.55 17.3,146.38 17.91,147 18.15,147 v2(18.27,146.88)
  BOTTOM w0.127: CN21.8 14.4,164.85 16.46,164.85 v1(16.79,164.52) 16.79,164.64 17.12,164.97 17.45,164.97 17.65,164.77 17.65,153.39 15.72,151.46 15.72,147.83 16.51,147.04 18.1,147.04 v2(18.27,146.88)
MIC_L1: length 3.7
  TOP w0.254: C574.2 190.35,10.72 v1(190.09,10.97) 189.06,12.01 U20.28
MIC_R1: length 3.4
  TOP w0.254: C571.2 190.4,11.86 v1(190.02,12.24) 189.75,12.51 U20.29
MINICAR_PME#: length 11.3
  TOP w0.127: CN22.1 173.43,162.61 v1(172.16,161.34) 170.97,160.15 R96.1 170.03,158.38 Q4.1 170.03,156.57 170.33,156.26 171.98,156.26 Q5.1
MPHY_PWREN: length 66.6
  TOP w0.127: PQ6.2 171.42,129.24 v2(171.52,129.13) ; v2(183.03,116.59) 183.03,116.08 183.83,115.28 184.21,115.28 v1(184.68,114.81) 184.73,114.76 184.73,113.04 185.62,112.15 185.62,110.64 186.1,110.16 186.1,107.65 187.15,106.6 187.15,106.16 187.48,105.84 187.48,99.04 186.4,97.97 184.99,97.97 182.12,95.1 179.27,95.1 178.33,94.16 v2(175.92,94.16)
  IN1 w0.14: v2(171.52,129.13) 171.75,129.13 172.11,128.78 172.11,128.32 171.35,127.56 171.35,121.97 172.23,121.09 178.53,121.09 v2(183.03,116.59)
  BOTTOM w0.076: U25.Y2 167.56,94.84 168.1,94.84 168.13,94.87 168.45,94.87
  BOTTOM w0.127: R544.1 176.54,94.78 v2(175.92,94.16) 175.92,94.29 175.28,94.92 R545.1 172.63,94.41 172.27,94.41 172.02,94.16 171.5,94.16 170.86,94.79 169.45,94.79 169.38,94.87 168.45,94.87
MS_BS: length 50.5
  TOP w0.127: v2(62.98,14.23) 62.54,14.68 62.54,15.31 62.58,15.36 U19.29 ; CN15.10 32.99,33.6 31.65,32.26 31.65,30.28 32.15,29.77 v2(32.15,29.26)
  BOTTOM w0.127: v2(62.98,14.23) 64.31,15.56 64.31,19.96 62.35,21.92 62.1,21.92 61.31,22.72 57.88,22.72 57.62,22.97 57.62,23.34 56.28,24.68 50.5,24.68 49.27,25.91 36.42,25.91 36.17,26.16 35.25,26.16 v1(32.87,28.55) v2(32.15,29.26)
MS_CLK: length 45.2
  TOP w0.127: R402.2 v2(56.54,16.56) ; v2(36.6,9.32) 36.22,9.7 EC70.1 35.96,9.32 35.84,9.2 34.24,9.2 32.54,10.9 32.54,12.12 32.74,12.33 CN15.9
  BOTTOM w0.127: v2(56.54,16.56) 47.39,16.56 45.36,14.53 45.36,14.35 46.18,13.53 46.18,13.32 46.03,13.17 45.82,13.17 44.48,14.51 44.27,14.51 44.12,14.36 44.12,14.15 46.26,12.01 46.26,11.8 46.11,11.65 45.9,11.65 43.74,13.81 43.53,13.81 43.38,13.66 43.38,13.45 44.81,12.03 44.81,11.82 44.66,11.67 44.45,11.67 43.02,13.09 42.81,13.09 41.55,11.83 39.11,11.83 v1(37.72,10.44) v2(36.6,9.32)
MS_D0: length 45.4
  TOP w0.127: v2(56.41,23.17) 56.41,22.02 56.67,21.76 C538.1 57.17,21.26 57.29,21.14 R390.2 ; CN15.5 32.16,24.83 v2(31.98,24.64)
  BOTTOM w0.127: v2(31.98,24.64) 32.97,24.64 33.58,24.03 36.7,24.03 37.18,23.55 38,23.55 38.57,22.97 42.72,22.97 42.85,23.1 42.85,23.93 43,24.08 43.21,24.08 43.36,23.93 43.36,23.1 43.48,22.97 43.74,22.97 43.86,23.1 43.86,23.98 44.01,24.13 44.22,24.13 44.37,23.98 44.37,23.1 44.5,22.97 44.75,22.97 44.88,23.1 44.88,23.98 45.03,24.13 45.24,24.13 45.39,23.98 45.39,23.1 45.52,22.97 45.77,22.97 45.9,23.1 45.9,24.01 46.04,24.16 46.26,24.16 46.4,24.01 46.4,23.1 46.53,22.97 46.79,22.97 46.91,23.1 46.91,24.06 47.06,24.21 47.27,24.21 47.42,24.06 47.42,23.1 47.55,22.97 47.8,22.97 47.93,23.1 47.93,24.01 48.08,24.16 48.29,24.16 48.44,24.01 48.44,23.1 48.56,22.97 48.82,22.97 48.94,23.1 48.94,23.93 49.09,24.08 49.3,24.08 49.45,23.93 49.45,23.1 49.58,22.97 50.85,22.97 50.98,23.1 50.98,23.56 51.1,23.68 51.36,23.68 51.48,23.56 51.48,23.1 51.61,22.97 54.02,22.97 v1(54.23,23.18) 56.4,23.18 v2(56.41,23.17)
MS_D1: length 44.9
  TOP w0.127: v2(35.23,27.99) 35.23,28.14 EC44.1 35.17,29.68 CN15.7 ; R377.2 v2(58.19,23.16)
  BOTTOM w0.127: v2(35.23,27.99) 35.76,27.99 36.09,27.66 40.33,27.66 40.46,27.53 40.46,26.39 40.59,26.26 40.84,26.26 40.97,26.39 40.97,27.62 41.09,27.74 41.35,27.74 41.48,27.62 41.48,26.39 41.6,26.26 41.86,26.26 41.98,26.39 41.98,27.61 42.1,27.73 42.36,27.73 42.49,27.6 42.49,26.39 42.62,26.26 42.87,26.26 43,26.39 43,27.53 43.13,27.66 43.38,27.66 43.51,27.53 43.51,26.39 43.63,26.26 43.89,26.26 44.02,26.39 44.02,27.67 44.16,27.81 44.37,27.81 44.52,27.67 44.52,26.39 44.65,26.26 44.9,26.26 45.03,26.39 45.03,27.57 45.18,27.72 45.39,27.72 45.54,27.57 45.54,26.39 45.67,26.26 45.92,26.26 46.05,26.39 46.05,27.36 46.35,27.66 48.06,27.66 50.47,25.25 v1(53.59,25.25) 56.22,25.25 58.19,23.28 v2(58.19,23.16)
MS_D2: length 45.5
  TOP w0.127: CN15.2 v2(32.33,17.33) ; v2(56.54,18.47) 56.87,18.47 57,18.59 R396.2
  BOTTOM w0.127: v2(32.33,17.33) 33.24,18.24 40.02,18.24 40.28,17.97 50.14,17.97 50.26,18.1 50.26,19.51 50.39,19.63 50.65,19.63 50.77,19.51 50.77,18.1 50.9,17.97 51.15,17.97 51.28,18.1 51.28,19.51 51.41,19.63 51.66,19.63 51.79,19.51 51.79,18.1 51.92,17.97 52.17,17.97 52.3,18.1 52.3,19.51 52.42,19.63 52.68,19.63 52.8,19.51 52.8,18.1 52.93,17.97 53.19,17.97 53.31,18.1 53.31,19.51 53.44,19.63 53.69,19.63 53.82,19.51 53.82,18.1 53.95,17.97 54.2,17.97 54.33,18.1 54.33,19.51 54.46,19.63 54.71,19.63 54.84,19.51 54.84,18.1 54.96,17.97 55.22,17.97 55.34,18.1 55.34,19.51 55.47,19.63 55.73,19.63 55.85,19.51 v2(55.85,18.97) 55.85,18.1 55.98,17.97 56.34,17.97 56.54,18.18 v2(56.54,18.47)
MS_D3: length 47.8
  TOP w0.127: CN15.1 35.03,14.83 35.33,14.53 35.33,13.64 35.9,13.07 35.9,11.32 35.96,11.26 EC67.1 35.43,11.25 v2(34.44,11.25) ; v2(56.54,17.58) R398.2
  BOTTOM w0.127: v2(34.44,11.25) 35.56,11.25 v1(35.69,11.38) 37.5,13.19 40.09,13.19 40.58,12.7 40.76,12.7 40.94,12.88 40.94,13.06 40.45,13.55 40.45,13.73 40.63,13.91 40.81,13.91 41.3,13.42 41.48,13.42 41.66,13.6 41.66,13.78 40.65,14.79 40.65,15 40.8,15.15 41.01,15.15 42.29,13.87 42.5,13.87 42.64,14.02 42.64,14.23 41.28,15.6 41.28,15.81 41.43,15.96 41.64,15.96 43,14.59 43.21,14.59 43.36,14.74 43.36,14.95 42.24,16.07 42.24,16.28 42.39,16.43 42.6,16.43 43.82,15.21 44.03,15.21 44.18,15.36 44.18,15.57 43.33,16.43 43.33,16.61 44.3,17.58 v2(56.54,17.58)
MUTE_LED_CNTL: length 187.9
  TOP w0.127: v1(21.31,40.08) 21.11,39.88 21.11,38.91 20.34,38.91 20.33,38.92 R335.1 19.58,38.86 20.12,38.33 20.12,36.37 20.32,36.17 25.38,36.17 28.62,32.93 28.62,26.37 27.38,25.12 27.38,14.75 v2(26.92,14.29) ; R431.1 173.76,6.15 174.17,5.74 v2(174.17,5.59)
  IN1 w0.14: v2(174.17,5.59) 173.99,5.77 172.39,5.77 171.22,4.6 125.11,4.6 122.62,7.09 92.3,7.09 90.57,8.81 64.63,8.81 61.87,11.57 40.73,11.57 40.05,12.25 30.07,12.25 28.03,14.29 v2(26.92,14.29)
MUTE_LED_CNTL_R: length 1.8
  TOP w0.127: R400.1 39.42,17.5 CN13.4
MUTE_LED_CNTL_R1: length 30.4
  TOP w0.127: R400.2 36.6,17.98 36.6,18.17 36.36,18.41 31.45,18.41 29.18,20.68 29.18,33.12 v1(24.41,37.9) Q22.3
MX0: length 57.6
  TOP w0.127: U11.58 48.4,62.88 v2(48.39,62.88) ; CN13.21 40.06,34.5 39.77,34.21 39.77,33.77 39.52,33.52 38.65,33.52 38.5,33.38 36.67,33.38 C481.1 35.69,33.96 35.43,34.21 v2(35.43,34.47)
  IN1 w0.14: v2(35.43,34.47) 36.16,35.19 38.65,35.19 39.72,36.26 39.72,39.87 43.84,43.99 43.84,46.03 45.35,47.54 45.35,48.7 44.35,49.71 40.99,49.71 40.82,49.54 38.03,49.54 37.36,50.22 37.36,51.74 39.24,53.62 39.24,60.07 40.59,61.41 42.77,61.41 43.82,62.47 45.24,62.47 46.15,63.38 47.89,63.38 v2(48.39,62.88)
MX1: length 64.8
  TOP w0.127: CN13.32 40.96,45.5 41.18,45.28 41.18,44.22 40.93,43.97 40.15,43.97 39.71,43.53 39.71,40.61 38.84,39.73 37.39,39.73 36.74,40.38 34.12,40.38 v1(33.81,40.69) C433.1 31.22,41.13 30.68,41.13 29.49,42.32 29.49,44.28 28.79,44.98 28.79,47.11 30.83,49.16 30.83,51.2 33.02,53.39 33.02,56.21 35.42,58.61 35.42,61.86 35.83,62.27 37.3,62.27 38.37,61.2 39.98,61.2 41.87,59.3 43.78,59.3 45.17,60.69 49.59,60.69 51.09,62.19 51.09,64.91 50.98,65.02 49,65.02 48.8,64.82 U11.59
MX2: length 51.3
  TOP w0.127: v2(49.07,62.84) 49.2,62.98 U11.60 ; CN13.25 39.79,38.5 v1(39.32,38.02) 39.07,37.78 38.31,37.78 38.13,37.6 C456.1 38.4,37.01 v2(38.73,37.33)
  IN1 w0.14: v2(38.73,37.33) 38.42,37.64 35.35,37.64 29.24,43.76 29.24,44.87 28.98,45.13 28.98,47.24 31.11,49.37 31.11,50.56 33.85,53.3 33.85,56.37 36.38,58.9 38.35,58.9 38.96,59.51 38.96,60.16 40.48,61.68 42.12,61.68 44.09,63.65 48.26,63.65 v2(49.07,62.84)
MX3: length 54.6
  TOP w0.127: v1(49.05,62.03) 49.7,62.68 v2(49.7,62.89) 49.6,62.99 U11.61 ; v2(39.01,36.2) 39.02,36.19 C462.1 39.52,35.98 39.52,37.09 39.93,37.5 CN13.24
  IN1 w0.14: v2(39.01,36.2) 38.28,35.46 37.16,35.46 28.97,43.65 28.97,44.76 28.6,45.13 28.6,47.24 30.84,49.48 30.84,50.68 33.58,53.41 33.58,56.48 37.25,60.16 37.63,60.16 39.42,61.95 42.01,61.95 43.98,63.91 48.72,63.91 49.7,62.93 v2(49.7,62.89)
MX4: length 60.1
  TOP w0.127: CN13.28 40.87,41.5 41.18,41.19 41.18,40.22 41.02,40.06 40.24,40.06 38.53,38.35 35.63,38.35 C442.1 35.13,38.72 30.37,38.72 29.31,39.78 29.31,40.33 28.72,40.92 28.72,43.97 28.03,44.67 28.03,47.99 v1(28.34,48.31) 28.7,48.66 29.26,48.66 30.05,49.45 30.05,51.49 32.26,53.7 32.26,56.53 34.65,58.93 34.65,62.18 35.51,63.03 37.61,63.03 38.69,61.96 41.96,61.96 42.41,62.41 43.86,62.41 44.82,61.45 49.27,61.45 50.15,62.33 50.15,63.07 50,63.22 U11.62
MX5: length 57.6
  TOP w0.127: CN13.27 40.32,40.5 38.61,38.79 C443.1 38.13,38.93 37.84,39.23 37.18,39.23 36.53,39.87 34.51,39.87 v1(34.06,39.42) 33.62,38.98 30.48,38.98 29.57,39.89 29.57,40.43 28.98,41.02 28.98,44.07 28.28,44.77 28.28,47.32 30.33,49.37 30.33,51.41 32.51,53.6 32.51,56.42 34.91,58.82 34.91,62.07 35.61,62.78 37.51,62.78 38.58,61.7 42.07,61.7 42.52,62.15 43.58,62.15 44.54,61.2 49.38,61.2 50.4,62.22 U11.63
MX6: length 60.1
  TOP w0.127: U11.64 50.8,62.26 49.48,60.94 45.06,60.94 43.68,59.56 41.98,59.56 40.08,61.45 38.48,61.45 37.4,62.52 35.72,62.52 35.16,61.97 35.16,58.72 32.76,56.32 32.76,53.49 30.58,51.31 30.58,49.26 28.53,47.22 28.53,44.88 29.23,44.18 29.23,41.13 29.87,40.49 29.87,39.94 30.58,39.23 31.21,39.23 C438.1 32.66,39.68 v1(32.79,39.8) 33.11,40.12 36.64,40.12 37.28,39.48 38.94,39.48 39.97,40.5 39.97,42.78 40.57,43.39 CN13.30
MX7: length 59.8
  TOP w0.127: CN13.31 40.32,44.5 39.46,43.63 39.46,41.91 C432.1 30.58,41.59 29.74,42.43 29.74,44.39 29.04,45.09 29.04,47.01 31.11,49.08 31.11,51.12 33.27,53.28 33.27,56.11 35.67,58.51 35.67,61.66 36.02,62 37.13,62 38.19,60.94 39.87,60.94 41.77,59.05 43.89,59.05 45.21,60.38 49.66,60.38 51.36,62.08 51.36,63.12 52.55,64.31 v1(53.21,64.31) 53.44,64.54 53.44,65.56 53.26,65.73 U11.65
MY0: length 46.5
  TOP w0.127: v2(39.55,62.93) 39.6,62.98 U11.36 ; RP3.7 27.74,42.98 28.28,42.44 v2(28.28,42.2) 28.28,41 29.06,40.22 29.06,39.29 v1(29.61,38.74) 29.88,38.47 34.81,38.47 35.19,38.08 C455.1 36.28,38.09 38.63,38.09 40.04,39.5 CN13.26
  IN1 w0.14: v2(28.28,42.2) 28.13,42.2 27.47,42.86 27.47,43.5 27.76,43.79 27.76,47.57 30.04,49.85 30.04,51.01 32.78,53.75 32.78,56.81 36.92,60.96 37.29,60.96 39.27,62.93 v2(39.55,62.93)
MY1: length 48.2
  TOP w0.127: v2(28.24,43.82) 28.24,44.04 28.04,44.25 RP3.9 ; CN13.22 40.17,35.5 39.9,35.23 39.9,34.84 C482.1 39.02,34.15 v2(38.63,34.54) ; v2(40.27,62.93) 40,63.2 U11.37
  IN1 w0.14: v2(40.27,62.93) 40.19,62.93 39.74,62.48 39.19,62.48 37.4,60.69 37.03,60.69 33.05,56.7 33.05,53.64 30.31,50.9 30.31,49.7 28.07,47.46 28.07,44.4 28.24,44.23 v2(28.24,43.82) 27.74,43.31 27.74,42.97 28.06,42.65 29.22,42.65 32.71,39.16 32.71,36.32 35.15,33.88 37.97,33.88 v2(38.63,34.54)
MY2: length 51.9
  TOP w0.127: CN13.20 40.09,33.5 C489.1 39.02,33.06 v2(39.01,33.07) ; RP3.1 26.15,44.88 26.34,45.07 26.34,45.31 26.16,45.49 v2(25.93,45.49) ; U11.38 40.4,65.05 v2(40.21,65.24)
  IN1 w0.14: v2(40.21,65.24) 40.21,64.63 37.07,61.49 36.66,61.49 32.25,57.08 32.25,53.97 27.11,48.83 27.11,47.48 25.93,46.31 v2(25.93,45.49) 25.93,42.93 27.56,41.3 28.82,41.3 32.44,37.68 32.44,36.21 35.13,33.53 38.56,33.53 v2(39.01,33.07)
MY3: length 63.6
  TOP w0.127: v2(38.58,28.7) 38.13,28.25 C497.1 38.78,28.12 v1(39.29,28.63) 39.42,28.5 CN13.15 ; v2(41.2,67.2) 40.8,66.81 U11.39 ; v2(28.27,38.68) 27.92,39.04 RP4.7
  IN1 w0.14: v2(41.2,67.2) 41.02,67.02 38.76,67.02 37.16,65.42 37.16,63.84 36.41,63.09 35.99,63.09 28.96,56.06 28.96,52.95 25.51,49.49 25.51,48.52 23.06,46.07 23.06,43.54 27.92,38.68 v2(28.27,38.68) 29.18,38.68 30.84,37.02 30.84,34.88 36.15,29.57 37.72,29.57 v2(38.58,28.7)
MY4: length 54.8
  TOP w0.127: RP3.2 25.22,44.25 v2(24.64,44.83) ; v2(35.43,32.44) C488.1 36.59,31.93 39.33,31.93 39.9,32.5 CN13.19 ; v2(41.27,65.24) 41.2,65.17 U11.40
  IN1 w0.14: v2(35.43,32.44) 35.43,32.85 32.18,36.1 32.18,37.57 28.71,41.03 27.45,41.03 25.36,43.13 25.36,44.12 v2(24.64,44.83) 24.64,45.77 26.84,47.97 26.84,48.94 31.98,54.08 31.98,57.19 36.55,61.76 36.96,61.76 39.12,63.92 39.12,65.42 39.39,65.69 40.51,65.69 40.96,65.24 v2(41.27,65.24)
MY5: length 47
  TOP w0.127: v2(34.59,35.76) 34.87,35.48 C461.1 36.53,35.04 39.33,35.04 39.5,35.2 39.5,35.56 39.77,35.84 39.77,36.27 40,36.5 CN13.23 ; v2(41.58,62.92) 41.58,62.92 41.6,62.94 U11.41 ; v2(28.24,43.1) 28.24,43.19 27.82,43.61 RP3.8
  IN1 w0.14: v2(34.59,35.76) 33.65,36.7 33.65,38.59 29.14,43.1 v2(28.24,43.1) 28.69,43.55 28.69,44.66 28.33,45.02 28.33,47.35 30.57,49.59 30.57,50.79 33.31,53.52 33.31,56.59 37.14,60.42 37.52,60.42 39.3,62.21 40.84,62.21 41.55,62.92 v2(41.58,62.92)
MY6: length 64.3
  TOP w0.127: CN13.16 39.54,29.5 39.3,29.26 C496.1 38.13,29.09 v2(37.74,28.69) ; RP4.6 27.9,38.41 v2(28.27,38.03) ; v2(41.84,67.2) 41.74,67.11 41.74,65.08 42,64.82 U11.42
  IN1 w0.14: v2(37.74,28.69) 37.14,29.3 36.04,29.3 30.58,34.77 30.58,36.81 29.11,38.28 28.52,38.28 v2(28.27,38.03) 28.19,38.03 22.79,43.43 22.79,46.18 25.24,48.63 25.24,49.6 28.7,53.06 28.7,56.17 35.88,63.36 36.3,63.36 36.89,63.95 36.89,65.53 38.65,67.29 39.98,67.29 40.35,67.66 41.39,67.66 v2(41.84,67.2)
MY7: length 58.1
  TOP w0.127: v2(37.74,30.86) 38.13,31.25 C492.1 39.24,31.42 v1(39.27,31.39) 39.37,31.5 CN13.18 ; v2(42.21,65.24) 42.4,65.05 U11.43 ; v2(24.64,44.15) 25.17,43.61 RP3.3
  IN1 w0.14: v2(37.74,30.86) 37.74,31.34 36.97,32.11 35.77,32.11 35.63,31.98 35.25,31.98 31.91,35.32 31.91,37.46 28.6,40.77 27.34,40.77 25.09,43.02 25.09,43.91 24.86,44.15 v2(24.64,44.15) 24.18,44.61 24.18,45.69 26.57,48.08 26.57,49.05 31.71,54.19 31.71,57.3 36.44,62.02 36.85,62.02 38.86,64.03 38.86,65.53 39.28,65.95 40.62,65.95 40.87,65.71 41.74,65.71 v2(42.21,65.24)
MY8: length 61.2
  TOP w0.127: v2(42.24,65.88) 42.65,65.46 42.65,65.12 42.8,64.97 U11.44 ; CN13.17 39.67,30.5 v1(39.27,30.1) 39.09,30.28 C493.1 38.13,30.33 v2(38.66,30.86) ; v2(24.64,43.51) 25.17,42.98 RP3.4
  IN1 w0.14: v2(42.24,65.88) 42.12,65.99 40.96,65.99 40.73,66.22 39.09,66.22 38.59,65.72 38.59,64.14 36.74,62.29 36.33,62.29 31.45,57.41 31.45,54.3 26.31,49.16 26.31,48.19 23.9,45.78 23.9,44.25 v2(24.64,43.51) 24.64,43.1 27.23,40.5 28.49,40.5 31.64,37.35 31.64,35.21 35.14,31.71 35.74,31.71 35.88,31.85 36.86,31.85 37.26,31.45 37.26,30.7 37.56,30.41 38.13,30.41 38.58,30.86 v2(38.66,30.86)
MY9: length 56.6
  TOP w0.127: RP3.6 27.61,42.34 27.83,42.12 v2(27.83,41.75) 28.03,41.56 28.03,40.9 28.81,40.12 28.81,38.81 29.84,37.77 v1(32.03,37.77) C451.1 34.42,36.51 38.59,36.51 40.07,38 41.27,38 41.44,38.16 41.44,42.2 41.14,42.5 CN13.29 ; U11.45 43.2,65.2 v2(43.12,65.28)
  IN1 w0.14: v2(43.12,65.28) 42.62,64.79 40.75,64.79 37.18,61.22 36.81,61.22 32.51,56.92 32.51,53.86 27.48,48.82 27.48,43.97 27.2,43.69 27.2,42.38 v2(27.83,41.75)
MY10: length 79
  TOP w0.127: v2(23.26,41.2) 24.03,40.44 v1(24.03,40.18) 24.53,39.68 RP4.3 ; CN13.10 39.57,23.5 39.02,22.95 C529.1 39.02,22.61 v2(38.63,22.22) ; U11.46 43.6,65.47 42.63,66.44 v2(42.63,68.27)
  IN1 w0.14: v2(42.63,68.27) 42.44,68.46 40.24,68.46 39.84,68.85 37.67,68.85 37.2,68.38 37.2,66.97 35.13,64.9 35.13,63.74 27.9,56.5 27.9,53.66 24.12,49.88 24.12,48.89 21.25,46.01 21.25,44.77 20.97,44.49 20.97,42.6 22.37,41.2 v2(23.26,41.2) 23.39,41.2 23.77,40.82 23.77,40.02 25.89,37.91 25.89,32.65 34.89,23.65 38.2,23.65 38.63,23.22 v2(38.63,22.22)
MY11: length 80
  TOP w0.127: v2(45.66,66.8) 45.43,66.56 45.43,65.68 45.6,65.5 U11.51 ; v2(38.54,24.39) 38.13,23.99 C522.1 39.27,23.8 39.97,24.5 CN13.11 ; v2(23.26,41.83) 23.77,41.83 v1(24.03,41.58) 24.15,41.45 24.15,40.79 24.64,40.31 RP4.2
  IN1 w0.14: v2(38.54,24.39) 38.54,24.34 38.13,23.93 34.98,23.93 29.65,29.26 29.65,30.38 26.15,33.87 26.15,38.02 24.08,40.09 24.08,41.1 23.34,41.83 v2(23.26,41.83) 22.11,41.83 21.23,42.72 21.23,44.38 21.51,44.66 21.51,45.9 24.39,48.78 24.39,49.77 28.16,53.55 28.16,56.39 35.4,63.63 35.4,64.79 37.46,66.86 37.46,68.27 37.78,68.58 39.73,68.58 40.13,68.19 42.07,68.19 43.47,66.8 v2(45.66,66.8)
MY12: length 69.3
  TOP w0.127: v2(28.24,39.4) 27.97,39.68 RP4.8 ; U11.52 46,65.19 45.87,65.32 v2(45.87,65.86) ; v2(37.75,26.53) 38.13,26.91 C498.1 39.04,27.1 v1(39.27,27.33) 39.44,27.5 CN13.14
  IN1 w0.14: v2(45.87,65.86) 45.74,66 43.13,66 42.5,66.62 41.08,66.62 40.95,66.75 38.87,66.75 37.42,65.31 37.42,63.73 36.52,62.82 36.1,62.82 30.91,57.63 30.91,54.52 25.77,49.38 25.77,48.41 23.34,45.98 23.34,43.64 27.57,39.41 28.24,39.41 v2(28.24,39.4) 28.24,39.41 28.83,39.41 31.11,37.13 31.11,34.99 36.22,29.87 38.05,29.87 39.03,28.89 39.03,27.81 v2(37.75,26.53)
MY13: length 68.9
  TOP w0.127: v2(28.24,40.05) 27.98,40.31 RP4.9 ; U11.53 46.4,65.41 46.36,65.45 v2(46.36,65.45) ; v2(38.63,26.47) 38.13,25.97 C509.1 39.17,25.96 v1(39.27,26.06) 39.71,26.5 CN13.13
  IN1 w0.14: v2(46.36,65.45) 46.32,65.41 45.68,65.41 45.36,65.73 43.02,65.73 42.41,66.35 40.98,66.35 40.84,66.49 38.98,66.49 38.32,65.83 38.32,64.25 36.63,62.56 36.22,62.56 31.18,57.52 31.18,54.41 26.04,49.27 26.04,48.3 23.62,45.88 23.62,43.74 27.31,40.05 v2(28.24,40.05) 28.57,40.05 31.38,37.24 31.38,35.1 36.33,30.14 38.16,30.14 39.3,29 39.3,27.14 v2(38.63,26.47)
MY14: length 75.9
  TOP w0.127: U11.54 46.8,66.3 v2(46.3,66.8) ; v2(37.74,24.38) 38.13,24.77 C516.1 39.09,24.94 v1(39.27,24.77) 40,25.5 CN13.12 ; RP4.1 v2(24.64,40.95)
  IN1 w0.14: v2(37.74,24.38) 34.91,24.38 29.91,29.37 29.91,30.49 26.42,33.98 26.42,38.13 24.64,39.91 v2(24.64,40.95) 24.64,41.17 23.43,42.38 21.95,42.38 21.5,42.83 21.5,44.27 21.78,44.55 21.78,45.68 24.92,48.82 24.92,49.65 28.43,53.17 28.43,56.28 35.77,63.62 36.19,63.62 36.62,64.06 36.62,65.64 38.54,67.55 39.87,67.55 40.24,67.92 41.96,67.92 43.54,66.35 45.85,66.35 v2(46.3,66.8)
MY15: length 84.9
  TOP w0.127: v2(23.26,40.56) 23.21,40.56 v1(22.73,40.08) 23.77,39.04 RP4.4 ; U11.55 47.2,65.93 v2(47.43,66.17) ; CN13.9 40.28,22.5 40.03,22.25 40.03,22.02 39.65,21.64 C539.1 39.02,21.78 v2(39.52,22.28)
  IN1 w0.14: v2(47.43,66.17) 47.43,66.3 46.49,67.25 44.28,67.25 43.08,68.45 43.08,68.46 42.81,68.72 40.35,68.72 39.95,69.12 37.56,69.12 36.93,68.49 36.93,67.08 34.87,65.02 34.87,63.97 27.53,56.64 27.53,53.67 23.86,50 23.86,49 20.98,46.12 20.98,44.88 20.7,44.6 20.7,42.49 22.63,40.56 v2(23.26,40.56) 23.26,40.15 25.62,37.8 25.62,32.54 35.71,22.44 36.53,22.44 37.34,21.64 38.88,21.64 v2(39.52,22.28)
MY16: length 67.4
  TOP w0.127: v2(36.6,21.29) 36.86,21.02 R389.2 37.36,20.63 37.82,21.08 38.56,21.08 C547.1 39.28,20.63 40.16,21.5 CN13.8 ; v2(47.12,62.89) 47.15,62.89 47.6,63.35 U11.56
  IN1 w0.14: v2(36.6,21.29) 39.17,21.29 39.98,22.1 39.98,39.76 44.22,43.99 44.22,45.9 45.62,47.3 45.62,48.82 44.46,49.97 40.88,49.97 40.71,49.81 38.15,49.81 37.63,50.33 37.63,51.63 39.51,53.51 39.51,59.96 40.7,61.15 42.88,61.15 43.93,62.2 46.43,62.2 v2(47.12,62.89)
MY17: length 69.1
  TOP w0.127: CN13.7 40.04,20.5 C552.1 38.42,18.89 37.09,18.89 36.86,19.12 R393.2 37.39,19.48 v2(37.51,19.36) ; U11.57 48,63.12 v2(47.76,62.88) 47.65,62.76 v1(47.65,62.03)
  IN1 w0.14: v2(37.51,19.36) 37.61,19.36 40.25,21.99 40.25,39.64 44.54,43.93 44.54,45.71 45.97,47.14 45.97,48.84 44.58,50.24 40.77,50.24 40.61,50.09 38.25,50.09 37.9,50.44 37.9,51.51 39.77,53.39 39.77,59.85 40.79,60.86 42.97,60.86 44.05,61.93 46.82,61.93 v2(47.76,62.88)
NB671PG: length 1.7
  BOTTOM w0.127: PU12.2 41.26,47.95 41.81,47.4 PR181.1
NBSWON1#: length 112
  TOP w0.127: U11.107 46.8,82.64 47.78,83.63 R224.2 49.05,84.1 v2(48.54,84.61) ; v2(36.47,174.55) 36.85,174.93 v1(36.85,176.2) 36.23,176.83 C50.1 35.71,175.91 35.8,175.82 CN5.6
  BOTTOM w0.127: v2(36.47,174.55) 35.46,173.53 35.46,172.77 31.65,168.96 31.65,149.23 31.14,148.72 31.14,118.47 30.57,117.9 30.57,113.9 41.95,102.52 41.95,97.59 46.4,93.13 46.4,86.74 47.11,86.03 v2(48.54,84.61)
ODD_EJECT#: length 274.8
  TOP w0.127: R181.2 190.4,91.61 v2(189.24,91.61) ; R181.2 190.77,91.74 v1(191.67,92.63) 191.67,94.79 192.68,95.81 200.02,95.81 v2(200.56,96.34) ; R181.2 190.52,90.86 192.33,89.05 ODD15.16 ; R227.2 39.19,83.8 40.96,83.8 41.57,83.19 v2(41.57,82.43)
  IN1 w0.14: ODD14.11 200.56,100.73 v2(200.56,96.34)
  IN2 w0.14: v2(189.24,91.61) 189.06,91.61 184.78,87.32 184.78,84.44 183.27,82.93 183.27,78.15 180.78,75.66 180.78,66.43 179.2,64.85 179.2,61.7 179.93,60.96 179.93,45.69 180.7,44.92 180.7,42.18 179.56,41.04 179.56,34.81 178.39,33.64 178.39,29.73 176.55,27.89 176.55,27.6 173.91,24.96 169.31,24.96 166.19,21.83 157.72,21.83 156.93,21.04 142.49,21.04 142.47,21.05 111.1,21.05 100.17,31.98 99.34,31.98 98.75,32.56 96.26,32.56 93.65,35.18 93.65,35.79 91.87,37.57 90.63,37.57 87.66,40.53 87.66,44 82.75,48.92 82.75,51.62 78.88,55.49 78.88,56.38 72.24,63.02 v2(72.24,63.17)
  BOTTOM w0.127: v2(72.24,63.17) 71.14,62.08 68.35,62.08 67.05,63.37 63.43,63.37 61.96,64.84 61.95,64.84 61.91,64.88 58.69,64.88 57.93,65.65 55.46,65.65 50.3,70.8 47.41,70.8 46.07,69.47 43.61,69.47 42.64,70.43 42.64,72.88 42.79,73.03 42.79,81.21 v2(41.57,82.43)
ODD_PRSNT#_R: length 7.3
  BOTTOM w0.127: R546.1 174.26,94.29 172.86,94.29 R553.2 171.14,93.78 v1(170.79,94.13) 170.79,94.13 170.53,94.38 169.54,94.38 169.31,94.62 167.98,94.62 U25.Y1
OVT_DETC: length 12
  TOP w0.127: R189.1 33.68,88.49 v1(33.42,88.24) 33.18,88 33.18,87.03 32.18,86.03 D6.2 32.18,84.29 31.29,83.4 31.29,82.05 31.57,81.78 33.68,81.78 34.06,82.16 Q16.2
PCH_DISP_ON: length 170
  IN1 w0.14: v2(61.49,176.2) 72.77,176.2 79.51,169.46 79.51,160.74 101.45,138.8 101.45,132.46 102.75,131.17 117.72,131.17 120.74,128.15 120.74,124.19 122.6,122.33 126.99,122.33 128.83,124.17 128.83,125.89 129.23,126.29 132.21,126.29 132.59,125.91 135.35,125.91 135.57,125.91 138.54,122.94 157.31,122.94 157.82,122.43 158.98,122.43 159.28,122.73 159.92,122.73 v2(160.15,122.5)
  BOTTOM w0.076: 164.76,106.35 164.76,105.27 164.31,104.83 164.31,104.49 U25.C6
  BOTTOM w0.127: v2(160.15,122.5) 160.35,122.3 164.79,122.3 164.97,122.12 164.97,121.43 165.77,120.63 165.77,120.21 165.38,119.81 165.38,106.97 164.76,106.35 ; U2.3 R31.2 56.7,177.24 61.92,177.24 v1(62.25,176.91) 62.2,176.91 v2(61.49,176.2)
PCH_DPST_PWM: length 154.5
  TOP w0.127: v2(60.76,169.65) R27.1
  IN1 w0.14: v2(60.76,169.65) 60.97,169.86 64.83,169.86 68.91,165.78 69.03,165.78 69.29,165.52 69.29,163.01 71.91,160.4 79.47,160.4 101.19,138.69 101.19,132.35 102.64,130.9 117.61,130.9 120.47,128.04 120.47,124.08 122.49,122.06 127.24,122.06 129.56,124.38 131.34,124.38 131.71,124.75 133.36,124.75 134.25,125.64 135.46,125.64 138.42,122.68 157.2,122.68 157.71,122.17 v2(159.38,122.17)
  BOTTOM w0.127: U25.B8 163.18,104.87 163.69,105.38 163.69,105.87 164.03,106.2 164.03,107 164.87,107.85 164.87,121.05 164.51,121.41 164.03,121.41 163.4,122.05 159.5,122.05 v2(159.38,122.17)
PCH_INVRMEN: length 7.1
  BOTTOM w0.076: U25.AV7 163.75,83.97 163.33,83.55 163.33,82.67 163.54,82.46 163.54,80.4 163.96,79.98
  BOTTOM w0.127: 163.96,79.98 165.25,78.69 R575.2
PCH_LVDS_BLON: length 184.1
  TOP w0.127: v2(44.35,164.9) 44.34,164.89 R2.2
  IN1 w0.14: v2(158.9,123.39) 158.9,123.34 158.53,122.97 158.04,122.97 157.53,123.48 138.76,123.48 135.77,126.46 132.8,126.46 131.32,127.94 v2(130.13,127.94) 128.3,126.11 128.3,124.39 126.77,122.86 122.82,122.86 121.27,124.41 121.27,128.37 117.94,131.7 102.97,131.7 102.19,132.48 102.19,140.31 80.05,162.45 80.05,169.71 72.54,177.22 56,177.22 52.3,173.52 51.77,173.52 44.35,166.09 v2(44.35,164.9)
  BOTTOM w0.127: v2(158.9,123.39) 158.9,121.97 159.22,121.65 160.56,121.65 160.7,121.79 163.22,121.79 163.85,121.16 164.4,121.16 164.59,120.97 164.59,110.13 163.14,108.69 163.14,106.5 162.46,105.82 U25.A9
PCH_OPI_RCOMP: length 7.7
  BOTTOM w0.102: 158.98,82.81 158.98,83 159.29,83.32 U25.AW15
  BOTTOM w0.127: v1(157.38,77.01) 157.76,77.01 158.22,77.48 R583.2 ; 158.98,82.81 158.93,82.77 158.93,81.27
  BOTTOM w0.254: R583.2 158.42,78.51 158.93,79.02 158.93,81.27
PCH_SLP_S0_N: length 281
  TOP w0.127: R213.2 36.74,85.4 v2(37.1,85.76) ; v2(181.45,72.18) 181.51,72.13 v1(181.51,71.43) 181.51,70.79 181.13,70.41 R283.2
  IN1 w0.14: v2(43.79,69.95) 43.79,69.8 44,69.59 49.26,69.59 49.43,69.42 51.54,69.42 53.74,67.22 53.74,64.52 54.61,63.65 54.61,61.83 58.58,57.85 58.58,55.64 62.49,51.73 62.49,43.57 62.51,43.56 62.51,42.67 62.77,42.4 62.77,39.63 62.57,39.43 62.57,33.3 63.09,32.78 63.09,29.08 65.82,26.36 66.69,26.36 73.93,19.13 78.87,19.13 79.32,19.58 83.16,19.58 83.62,19.13 85.44,19.13 86.25,18.31 91.35,18.31 91.69,18.66 108.51,18.66 109.4,19.54 110.06,19.54 132.44,19.54 132.97,20.07 158.7,20.07 159.37,20.74 165.64,20.74 165.82,20.56 170.08,20.56 170.41,20.89 171.08,21.56 175.64,21.56 182.23,28.15 182.23,36.93 182.9,37.61 182.9,40.74 183.34,41.17 183.34,47.03 183.34,48.9 183.64,49.2 183.64,64.49 181.75,66.37 181.75,71.88 v2(181.45,72.18) 180.57,73.07 180.57,74.85 177.11,78.31 177.11,79.4 178.27,80.56 178.27,83.73 175,86.99 175,89.11 174.2,89.91 170.94,89.91 v2(169.1,91.75)
  BOTTOM w0.076: 168.68,92.15 168.19,92.15 167.99,91.95 167.71,91.95 167.56,91.8 167.56,91.44 167.38,91.26 166.87,91.26 U25.AF3
  BOTTOM w0.127: 168.68,92.15 169.08,91.75 v2(169.1,91.75) ; v2(43.79,69.95) 43.76,69.95 43.05,70.66 43.05,81.58 40.63,84 38.86,84 v2(37.1,85.76)
PCH_SPI1_CLK: length 30.8
  IN1 w0.14: v2(166.91,93.42) 167,93.42 168.53,94.95 170.38,94.95 171.27,95.83 171.27,96.31 171.42,96.46 171.42,97.89 170.67,98.64 170.67,99.28 171.14,99.75 172.26,99.75 173.35,98.65 174.12,98.65 174.67,99.21 174.67,99.51 175.26,100.1 186.71,100.1 187.18,100.57 v2(188.87,100.57)
  BOTTOM w0.127: v2(166.91,93.42) 166.91,93.54 U25.AA3 ; R505.2 188.5,101.55 188.87,101.18 v2(188.87,100.57)
PCH_SPI1_CLK_R: length 170.9
  TOP w0.127: TP30.1 184.02,116.32 v2(184.02,115.82) ; R225.2 51.2,93.65 v2(51.84,94.29)
  IN1 w0.14: v2(51.84,94.29) 52.33,94.78 55.26,94.78 55.87,95.39 78.55,95.39 102.01,118.85 109.16,118.85 110.23,117.78 114.2,117.78 115.75,119.33 129.31,119.33 133.18,115.46 144.23,115.46 144.88,115.46 147.82,118.41 154.26,118.41 155.46,117.21 160.79,117.21 161.31,116.69 167.99,116.69 170.5,119.2 178.3,119.2 181.69,115.82 v2(184.02,115.82)
  BOTTOM w0.127: v2(184.02,115.82) 184.79,115.05 185.38,115.05 186.49,113.94 188.06,113.94 189.04,112.97 189.04,111.42 187.35,109.73 187.35,107.87 186.21,106.73 U23.6 U24.6 186.21,104.52 186.71,104.01 186.71,103.88 187.72,102.87 C716.1 R505.1
PCH_SPI1_SI: length 27
  IN1 w0.14: v2(188.87,99.79) 187.5,99.79 186.82,99.12 176.23,99.12 175.46,98.35 175.46,96.9 173.25,94.69 173.24,94.69 172.26,93.7 172.01,93.7 172,93.69 168.95,93.69 v2(168.48,93.22)
  BOTTOM w0.127: v2(188.87,99.79) 189.63,100.55 R507.2 ; U25.AA2 167.64,93.42 168.27,93.42 v2(168.48,93.22)
PCH_SPI1_SI_R: length 168.2
  TOP w0.127: v2(54.41,94.01) 53.69,93.28 R226.2 ; TP28.1 185.62,115.86 v2(185.57,115.81)
  IN1 w0.14: v2(54.41,94.01) 55.58,94.01 55.94,94.36 78.96,94.36 102.05,117.45 109.46,117.45 110.02,116.89 114.96,116.89 115.85,117.78 129.74,117.78 132.83,114.69 142.71,114.69 143.7,113.7 156.59,113.7 158.8,115.92 168.49,115.92 171,118.43 176.66,118.43 176.91,118.17 178.23,118.17 181.37,115.04 184.8,115.04 v2(185.57,115.81)
  BOTTOM w0.127: R507.1 189.63,102.92 188.62,103.94 187.73,103.94 187.48,104.19 U24.5 U23.5 187.48,106.55 188.11,107.19 188.11,109.4 189.8,111.09 189.8,113.5 188.59,114.71 186.8,114.71 185.7,115.81 v2(185.57,115.81)
PCH_SPI1_SO: length 38.2
  IN2 w0.14: v2(169.75,93.26) 172.17,93.26 173.21,92.22 174.87,92.22 177.54,94.89 182.39,94.89 183.33,95.83 183.33,96.04 184.68,97.38 184.68,99.52 184.36,99.84 184.36,102.29 184.78,102.7 184.78,108.44 v2(182.99,110.24)
  BOTTOM w0.076: U25.AA4 166.26,94.13 166.72,94.13 166.76,94.09 168.81,94.09
  BOTTOM w0.127: R489.2 180.77,110.68 181.82,110.68 181.9,110.6 182.62,110.6 v2(182.99,110.24) ; v2(169.75,93.26) 168.92,94.09 168.81,94.09
PCH_SPI1_SO_R: length 162.8
  TOP w0.127: v2(53.35,94.01) 53.08,94.01 R212.2 ; v2(185.24,114.02) 185.56,113.7 TP23.1
  IN1 w0.14: v2(185.24,114.02) 185.24,114.43 185.09,114.58 181.27,114.58 178.07,117.78 176.75,117.78 176.49,118.03 171.17,118.03 168.66,115.53 158.97,115.53 156.75,113.31 143.53,113.31 142.55,114.29 135.48,114.29 134.64,113.46 130.96,113.46 130.33,114.1 130.33,116.28 129.69,116.92 116.25,116.92 115.24,115.9 110.43,115.9 109.29,117.04 102.2,117.04 79.12,93.97 56.1,93.97 55.69,93.55 54.67,93.55 54.33,93.22 52.47,93.22 52.35,93.35 52.35,93.65 52.47,93.78 53.12,93.78 v2(53.35,94.01)
  BOTTOM w0.127: v2(185.24,114.02) 184.94,113.72 U24.2 U23.2 184.94,111.91 184.01,110.99 182.06,110.99 181.94,111.11 180.41,111.11 R489.1
PCH_SPI_CS0#: length 40.8
  IN2 w0.14: v2(164.15,94.89) 164.61,95.35 165.82,95.35 166.89,94.27 168.06,94.27 168.22,94.1 173.12,94.1 173.35,94.33 174.44,94.33 175.79,95.68 181.2,95.68 182.16,96.64 182.82,96.64 183.89,97.71 183.89,99.2 183.58,99.51 183.58,102.83 183.99,103.24 183.99,106.81 181.18,109.62 181.18,110.73 181.89,111.43 v2(182.27,111.43)
  BOTTOM w0.089: U25.Y7 164.15,94.59 v2(164.15,94.89)
  BOTTOM w0.127: R488.2 180.42,111.49 182.21,111.49 v2(182.27,111.43)
PCH_SPI_CS0#_R: length 166.5
  TOP w0.127: v2(54.75,92.75) 54.06,92.06 54.06,88.82 54.19,88.7 54.86,88.7 54.99,88.57 54.99,88.32 54.86,88.19 54.19,88.19 54.06,88.06 54.06,87.81 54.19,87.68 54.73,87.68 54.86,87.55 54.86,87.3 54.73,87.17 54.13,87.17 53.49,86.54 R220.2 ; v2(182.38,114.08) TP24.1
  IN1 w0.14: v2(182.38,114.08) 181.21,114.08 177.91,117.38 176.59,117.38 176.33,117.64 171.33,117.64 167.94,114.25 161.35,114.25 160.01,112.92 143.39,112.92 142.55,112.07 129.86,112.07 129.18,112.75 129.18,115.75 128.55,116.38 116.61,116.38 115.47,115.24 110.53,115.24 109.14,116.64 102.35,116.64 99.48,113.77 98.88,113.16 93.37,107.66 79.29,93.57 56.27,93.57 55.44,92.75 v2(54.75,92.75)
  BOTTOM w0.127: v2(182.38,114.08) 182.82,114.52 183.32,114.52 183.67,114.18 U24.1 U23.1 183.67,111.89 183.51,111.73 182.75,111.73 181.15,113.34 180.08,113.34 180.03,113.28 180.03,112.66 R488.1
PCH_SPI_IO2: length 37.5
  IN2 w0.14: v2(181.63,110.24) 184.38,107.49 184.38,103.08 183.97,102.67 183.97,99.67 184.28,99.36 184.28,97.54 182.94,96.2 182.94,96 182.22,95.28 176.28,95.28 174.9,93.9 173.66,93.9 173.46,93.71 168.06,93.71 167.9,93.87 166.12,93.87 165.53,94.46 165.33,94.46 v2(164.87,94.92)
  BOTTOM w0.076: v2(164.87,94.92) 164.63,94.68 U25.Y6
  BOTTOM w0.127: v2(181.63,110.24) 181.05,109.65 R490.2
PCH_SPI_IO3: length 28
  IN1 w0.14: v2(168.46,91.75) 168.46,92.04 168.7,92.27 169.46,92.27 170.43,93.24 172.36,93.24 172.84,93.72 172.84,93.72 173.41,94.29 173.41,94.29 176.14,97.02 178.39,97.02 178.66,97.29 185.66,97.29 186.44,98.08 187.26,98.08 187.9,98.72 188.46,98.72 v2(188.87,99.14)
  BOTTOM w0.127: v2(168.46,91.75) 168.26,91.55 U25.AF1 ; v2(188.87,99.14) 188.46,99.14 187.09,100.5 187.09,100.79 186.47,101.41 R504.1
PCH_XTAL24_IN: length 102.9
  TOP w0.127: R209.1 69.49,86.78 C320.2 70.5,87.29 73.05,89.84 v1(73.94,89.84) 77.46,89.84 98.07,110.44 98.07,112.88 102.75,117.56 117.64,117.56 118.25,118.16 128.25,118.16 129.28,119.19 131.91,119.19 132.71,119.99 134.34,119.99 135.23,119.1 138.1,119.1 139.01,120.02 146.58,120.02 147.93,118.67 153.49,118.67 154.58,117.57 R147.2
PCH_XTAL24_IN_R: length 2.8
  TOP w0.127: R209.2 69.49,84.96 69.82,84.63 v2(69.82,84.3) 69.82,83.95 69.6,83.73 U9.5
PCI_SERR#: length 290.7
  TOP w0.127: U11.99 50,78.2 47.07,75.27 47.07,73.48 48.08,72.47 v2(48.08,68.38)
  IN1 w0.14: v2(179.8,96.22) 179.62,96.03 179.62,96.03 179.35,95.76 178.8,95.76 175.92,92.88 175.92,87.48 179.2,84.2 179.2,78.86 182.89,75.16 182.89,66.74 184.73,64.9 184.73,62.91 189.3,58.34 189.3,54.95 185.91,51.56 185.91,47.54 184.52,46.15 184.52,42.68 184.88,42.32 184.88,36.45 183.03,34.59 183.03,27.82 175.97,20.76 171.5,20.76 169.03,18.29 167.03,18.29 166.72,18.6 166.72,18.92 166.37,19.28 162.52,19.28 161.85,19.94 159.87,19.94 159.2,19.27 134.95,19.27 134.42,18.74 110.36,18.74 108.74,17.12 105.73,17.12 105,17.86 92.02,17.86 91.68,17.51 85.56,17.51 85.41,17.66 82.16,17.66 81.39,18.43 80.38,18.43 79.17,17.22 73.44,17.22 69.21,21.44 69.21,22.71 66.83,25.1 65.95,25.1 62.03,29.02 62.03,29.5 61.33,30.19 61.33,51.76 57.76,55.33 57.76,57.55 54.27,61.04 53.81,61.5 53.81,63.32 53.05,64.08 52.89,64.24 52.89,65.8 50.86,67.83 49.12,67.83 48.59,68.36 48.36,68.36 48.34,68.38 v2(48.08,68.38)
  IN2 w0.14: v2(179.8,96.22) 179.62,96.43 179.62,96.43 179.36,96.69 178.96,96.69 178.74,96.47 175.43,96.47 174.08,95.12 172.55,95.12 172.28,95.39 170.93,95.39 170.43,94.89 168.55,94.89 167.81,95.64 166.34,95.64 165.67,96.3 165.16,96.3 164.8,95.94 v2(164.8,95.84)
  BOTTOM w0.089: U25.V6 164.8,95.54 v2(164.8,95.84)
  BOTTOM w0.127: R527.1 179.8,96.38 v2(179.8,96.22)
PCIE_CLKREQ0#: length 5.7
  BOTTOM w0.076: R534.1 172.02,97.08 171.98,97.04 170.8,97.04 170.4,96.63 169.3,96.63 168.74,96.08 168.32,96.08 168.06,96.34 167.56,96.34 U25.U2
PCIE_CLKREQ1#: length 28.9
  TOP w0.127: R268.1 178.61,74.73 v2(178.59,74.75)
  IN1 w0.14: v3(164.83,93.94) 165.3,93.47 165.73,93.47 166.7,92.5 166.96,92.5 167.38,92.08 167.38,90.08 167.77,89.7 167.77,87.38 168.15,87 169.99,87 170.28,86.72 170.28,81.09 174.99,76.38 176.21,76.38 177.51,75.08 178.26,75.08 v2(178.59,74.75)
  BOTTOM w0.076: U25.Y5 165.28,94.39 v3(164.83,93.94)
PCIE_CLKREQ5#: length 9.5
  BOTTOM w0.076: 171.91,97.52 171.6,97.21 170.73,97.21 170.33,96.8 169.23,96.8 168.67,96.24 168.39,96.24 168.13,96.5 167.56,96.5 U25.T2
  BOTTOM w0.127: 171.91,97.52 172.03,97.64 173.51,97.64 174.19,96.95 174.91,96.95 R158.1
PCIE_CLKREQ_CR#: length 236
  TOP w0.127: v2(165.46,96.8) 165.53,96.86 167.27,96.86 168.1,97.69 168.1,98.05 168.47,98.43 170.36,98.43 170.48,98.55 v1(170.66,98.55) 171.04,98.55 v2(171.45,98.96) 172.44,99.95 172.74,99.95 173.61,100.81 176.1,100.81 176.92,99.99 181.85,99.99 183.13,101.27 183.13,103.82 183.5,104.19 183.5,104.83 R535.1 ; U19.2 65.85,17.21 65.99,17.07 v1(67.08,17.07) 68.56,17.07 72.08,20.6 72.08,21.6 v2(73,22.51)
  IN1 w0.14: v2(73,22.51) 73.31,22.2 73.81,22.2 75.41,20.6 84.68,20.6 85.39,19.89 85.82,19.89 86.16,19.55 88.42,19.55 88.61,19.37 106.16,19.37 107.52,20.73 115.06,20.73 115.8,19.98 132.08,19.98 132.61,20.51 157.41,20.51 158.09,21.18 166.67,21.18 166.85,21.01 169.9,21.01 170.23,21.34 170.23,21.34 170.9,22 175.45,22 181.78,28.33 181.78,37.11 182.46,37.79 182.46,41.11 182.89,41.55 182.89,46.85 182.89,46.85 182.89,47.59 182.89,47.59 182.89,53.67 182.54,54.03 182.54,54.83 182.61,54.9 182.61,59.8 183.03,60.22 183.03,64.47 181.31,66.19 181.31,71.34 180,72.66 180,74.8 178.69,76.1 177.6,76.1 177.39,76.3 177.39,76.96 176.81,77.55 174.47,77.55 171.97,80.04 171.05,80.96 170.77,81.24 170.76,81.25 170.76,87.61 171,87.85 171,88.74 170.69,89.05 169.44,89.05 167.94,90.55 167.94,93.47 168.69,94.22 171.79,94.22 172.74,95.17 172.74,97.66 v2(171.45,98.96)
  BOTTOM w0.076: v2(165.46,96.8) 165.28,96.62 U25.U5
